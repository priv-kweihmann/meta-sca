inherit setuptools3
require python-flake8-native.inc

SRC_URI[md5sum] = "147957dd7f8af16117ae5c3e6b82df74"
SRC_URI[sha256sum] = "19241c1cbc971b9962473e4438a2ca19749a7dd002dd1a946eaba171b4114548"
