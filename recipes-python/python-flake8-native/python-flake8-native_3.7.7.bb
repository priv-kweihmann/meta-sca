inherit setuptools
require python-flake8-native.inc

SRC_URI[md5sum] = "fd84dd29950a9da4ab6264ff90e8282b"
SRC_URI[sha256sum] = "859996073f341f2670741b51ec1e67a01da142831aa1fdc6242dbf88dffbe661"
