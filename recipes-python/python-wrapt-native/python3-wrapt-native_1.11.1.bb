inherit setuptools
require python-wrapt-native.inc

SRC_URI[md5sum] = "9f21acd7c0a57bf3057715c4665db3c7"
SRC_URI[sha256sum] = "4aea003270831cceb8a90ff27c4031da6ead7ec1886023b80ce0dfe0adf61533"
