SUMMARY = "wrapt"
DESCRIPTION = "Module for decorators, wrappers and monkey patching"
HOMEPAGE = "http://wrapt.readthedocs.org/"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdfc019b57affbe1d7a32e3d34e83db4"

PYPI_PACKAGE = "wrapt"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "f7830879766791fab0dfca86c8725226"
SRC_URI[sha256sum] = "0ec40d9fd4ec9f9e3ff9bdd12dbd3535f4085949f4db93025089d7a673ea94e8"
