inherit setuptools
require python-eradicate-native.inc

SRC_URI[md5sum] = "8a5f643c9054285123b3809844fbcea2"
SRC_URI[sha256sum] = "4ffda82aae6fd49dfffa777a857cb758d77502a1f2e0f54c9ac5155a39d2d01a"
