inherit setuptools
require python-jinja2-native.inc

SRC_URI[md5sum] = "61ef1117f945486472850819b8d1eb3d"
SRC_URI[sha256sum] = "f84be1bb0040caca4cea721fcbbbbd61f9be9464ca236387158b0feea01914a4"
