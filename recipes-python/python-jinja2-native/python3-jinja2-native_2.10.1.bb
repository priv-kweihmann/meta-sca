inherit setuptools3
require python-jinja2-native.inc

SRC_URI[md5sum] = "0ae535be40fd215a8114a090c8b68e5a"
SRC_URI[sha256sum] = "065c4f02ebe7f7cf559e49ee5a95fb800a9e4528727aec6f24402a5374c65013"
