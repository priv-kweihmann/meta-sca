inherit setuptools3
require python-pygments-native.inc

SRC_URI[md5sum] = "465a35559863089d959d783a69f79b9f"
SRC_URI[sha256sum] = "98c8aa5a9f778fcd1026a17361ddaf7330d1b7c62ae97c3bb0ae73e0b9b6b0fe"
