inherit setuptools
require python-pygments-native.inc

SRC_URI[md5sum] = "a5095f15bdebf6faafa8efc9f49b5e9c"
SRC_URI[sha256sum] = "31cba6ffb739f099a85e243eff8cb717089fdd3c7300767d9fc34cb8e1b065f5"
