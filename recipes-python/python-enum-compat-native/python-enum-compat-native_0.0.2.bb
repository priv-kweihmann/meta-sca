inherit setuptools
require python-enum-compat-native.inc

SRC_URI[md5sum] = "3002940b6620837d0fbc86ec72509be3"
SRC_URI[sha256sum] = "939ceff18186a5762ae4db9fa7bfe017edbd03b66526b798dd8245394c8a4192"
