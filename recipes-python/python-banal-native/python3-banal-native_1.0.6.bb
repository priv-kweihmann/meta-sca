SUMMARY = "Commons of banal micro-functions for Python"
HOMEPAGE = "http://github.com/pudo/banal"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c6864b0f90b7b849410f1b22ea10ae44"

PYPI_PACKAGE = "banal"

SRC_URI[md5sum] = "eee3dba88d495b5f9c54a971ba4da31b"
SRC_URI[sha256sum] = "2fe02c9305f53168441948f4a03dfbfa2eacc73db30db4a93309083cb0e250a5"

inherit pypi
inherit setuptools3
inherit native
