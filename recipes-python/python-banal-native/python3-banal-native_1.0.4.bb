SUMMARY = "Commons of banal micro-functions for Python"
HOMEPAGE = "http://github.com/pudo/banal"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c6864b0f90b7b849410f1b22ea10ae44"

PYPI_PACKAGE = "banal"

SRC_URI[md5sum] = "c01b2c9233a3ac2d94f7c9297312338b"
SRC_URI[sha256sum] = "7940f0a32d8b4a52a94dd52d79d8d49f51c8dcc61a23a3c69a58a40129d98cc3"

inherit pypi
inherit setuptools3
inherit native
