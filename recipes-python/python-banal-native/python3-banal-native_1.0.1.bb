SUMMARY = "Commons of banal micro-functions for Python"
HOMEPAGE = "http://github.com/pudo/banal"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c6864b0f90b7b849410f1b22ea10ae44"

PYPI_PACKAGE = "banal"

SRC_URI[md5sum] = "2f00791147bd751beb1348795f0c3dd4"
SRC_URI[sha256sum] = "5541e7c98ea04841f4ff2887bbc3f2dccf982549a99d01c0939aac250fffcf7a"

inherit pypi
inherit setuptools3
inherit native
