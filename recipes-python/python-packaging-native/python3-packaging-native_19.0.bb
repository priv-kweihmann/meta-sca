inherit setuptools3
require python-packaging-native.inc

SRC_URI[md5sum] = "dd118dc389f8e90840d44240292bf3d9"
SRC_URI[sha256sum] = "0c98a5d0be38ed775798ece1b9727178c4469d9c3b4ada66e8e6b7849f8732af"

