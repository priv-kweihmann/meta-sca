inherit setuptools
require python-ansible-native.inc

DEPENDS += "${PYTHON_PN}-pyyaml-native ${PYTHON_PN}-jinja2-native ${PYTHON_PN}-native"
