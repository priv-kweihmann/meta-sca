inherit setuptools
require python-configparser-native.inc

SRC_URI[md5sum] = "aaa80b58b6b0810e54f66486860b3ed1"
SRC_URI[sha256sum] = "da60d0014fd8c55eb48c1c5354352e363e2d30bbf7057e5e171a468390184c75"
