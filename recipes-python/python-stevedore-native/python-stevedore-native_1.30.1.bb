inherit setuptools
require python-stevedore-native.inc

SRC_URI[md5sum] = "02c747c39f4634465aa2590ceefddf59"
SRC_URI[sha256sum] = "7be098ff53d87f23d798a7ce7ae5c31f094f3deb92ba18059b1aeb1ca9fec0a0"
