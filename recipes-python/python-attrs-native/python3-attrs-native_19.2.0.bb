SUMMARY = "Classes Without Boilerplate"
DESCRIPTION = "Classes Without Boilerplate"
HOMEPAGE = "https://github.com/python-attrs/attrs"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ab25949a73fe7d4fdee93bcbdbf8ff"

PYPI_PACKAGE = "attrs"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "d5a6ee80beaa072bd2b3bcb6fee0d508"
SRC_URI[sha256sum] = "f913492e1663d3c36f502e5e9ba6cd13cf19d7fab50aa13239e420fef95e1396"
