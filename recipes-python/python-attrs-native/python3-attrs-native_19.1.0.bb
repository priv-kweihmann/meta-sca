inherit setuptools3
require python-attrs-native.inc

SRC_URI[md5sum] = "2be7bce157988928f5ff2bb50a0b510d"
SRC_URI[sha256sum] = "f0b870f674851ecbfbbbd364d6b5cbdff9dcedbc7f3f5e18a6891057f21fe399"
