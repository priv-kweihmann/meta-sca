SUMMARY = "Classes Without Boilerplate"
DESCRIPTION = "Classes Without Boilerplate"
HOMEPAGE = "https://github.com/python-attrs/attrs"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ab25949a73fe7d4fdee93bcbdbf8ff"

PYPI_PACKAGE = "attrs"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "5b2db50fcc31be34d32798183c9bd062"
SRC_URI[sha256sum] = "f7b7ce16570fe9965acd6d30101a28f62fb4a7f9e926b3bbc9b61f8b04247e72"
