SUMMARY = "Classes Without Boilerplate"
HOMEPAGE = "https://github.com/python-attrs/attrs"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ab25949a73fe7d4fdee93bcbdbf8ff"

PYPI_PACKAGE = "attrs"

SRC_URI[md5sum] = "ab7533fc91c5db3d5b65e66be907444e"
SRC_URI[sha256sum] = "0ef97238856430dcf9228e07f316aefc17e8939fc8507e18c6501b761ef1a42a"

inherit pypi
inherit native
inherit setuptools3
