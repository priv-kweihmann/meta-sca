SUMMARY = "Internationalized Domain Names for Python"
DESCRIPTION = "Internationalized Domain Names for Python"
HOMEPAGE = "https://github.com/kjd/idna"
LICENSE = "Python-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=782775b32f96098512e283fb5d4546cd"

PYPI_PACKAGE = "idna"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "2e9ae0b4a0b26d1747c6127cdb060bc1"
SRC_URI[sha256sum] = "c357b3f628cf53ae2c4c05627ecc484553142ca23264e593d327bcde5e9c3407"
