inherit setuptools
require python-idna-native.inc

SRC_URI[md5sum] = "2e9ae0b4a0b26d1747c6127cdb060bc1"
SRC_URI[sha256sum] = "c357b3f628cf53ae2c4c05627ecc484553142ca23264e593d327bcde5e9c3407"
