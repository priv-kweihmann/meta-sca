inherit setuptools3
require python-appdirs-native.inc

SRC_URI[md5sum] = "44c679904082a2133f5566c8a0d3ab42"
SRC_URI[sha256sum] = "9e5896d1372858f8dd3344faf4e5014d21849c756c8d5701f78f8a103b372d92"
