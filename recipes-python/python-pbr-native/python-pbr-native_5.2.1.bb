inherit setuptools
require python-pbr-native.inc

SRC_URI[md5sum] = "f72c2dd10602abad3695097d634e94bb"
SRC_URI[sha256sum] = "93d2dc6ee0c9af4dbc70bc1251d0e545a9910ca8863774761f92716dece400b6"
