inherit setuptools3
require python-flake8-eradicate-native.inc

SRC_URI[md5sum] = "b17abdf11b55b2aaed3944088927c8e3"
SRC_URI[sha256sum] = "a42c501d40b2beb6bcbbcb961169b16a7794b179dcc990cb317c2e655c19e379"
