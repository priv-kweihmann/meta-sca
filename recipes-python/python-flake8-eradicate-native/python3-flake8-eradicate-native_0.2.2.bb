inherit setuptools3
require python-flake8-eradicate-native.inc

SRC_URI[md5sum] = "7895734c40b795461385878ff4161cf5"
SRC_URI[sha256sum] = "f4270cc2584a73fb87bdcce044a198248e72d0253162a8a12333b2c427a18f51"
