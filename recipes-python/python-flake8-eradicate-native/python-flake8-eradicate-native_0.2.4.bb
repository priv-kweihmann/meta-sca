inherit setuptools
require python-flake8-eradicate-native.inc

SRC_URI[md5sum] = "b18f3b7d88c21b911ae85d40399d2efd"
SRC_URI[sha256sum] = "b693e9dfe6da42dbc7fb75af8486495b9414d1ab0372d15efcf85a2ac85fd368"
