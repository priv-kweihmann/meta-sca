inherit setuptools3
require python-flake8-eradicate-native.inc

SRC_URI[md5sum] = "d0100d7f12388845eb63ead6e727bef9"
SRC_URI[sha256sum] = "cc2c3300a6643f8347988cc828478c347975f7bf9c8fc1f8a7027da41ab9bdbd"
