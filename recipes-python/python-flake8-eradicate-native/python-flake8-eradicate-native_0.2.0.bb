inherit setuptools
require python-flake8-eradicate-native.inc

SRC_URI[md5sum] = "be5cca7ba2c818780093d5970580cc6c"
SRC_URI[sha256sum] = "c762fbb5c3e3694c9ba656d38477b2dcca6599b8baeee4984d05d655591a6f83"
