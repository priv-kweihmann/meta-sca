inherit setuptools
require python-pytest-runner-native.inc