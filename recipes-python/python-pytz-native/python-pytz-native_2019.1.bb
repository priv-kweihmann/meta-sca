inherit setuptools
require python-pytz-native.inc

SRC_URI[md5sum] = "8b2860a161bfb0a6165798b1a2d8c40c"
SRC_URI[sha256sum] = "d747dd3d23d77ef44c6a3526e274af6efeb0a6f1afd5a69ba4d5be4098c8e141"
