SUMMARY = "World timezone definitions, modern and historical"
HOMEPAGE = "https://pythonhosted.org/pytz/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1a67fc46c1b596cce5d21209bbe75999"

PYPI_PACKAGE = "pytz"

SRC_URI[md5sum] = "e7ebdeb16f0e0abdddc0e764af68052c"
SRC_URI[sha256sum] = "180befebb1927b16f6b57101720075a984c019ac16b1b7575673bea42c6c3da5"

inherit pypi
inherit native
inherit setuptools3
