SUMMARY = "World timezone definitions, modern and historical"
HOMEPAGE = "https://pythonhosted.org/pytz/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1a67fc46c1b596cce5d21209bbe75999"

PYPI_PACKAGE = "pytz"

SRC_URI[md5sum] = "0349106ac02f2bfe565dd6d5594e3a15"
SRC_URI[sha256sum] = "c35965d010ce31b23eeb663ed3cc8c906275d6be1a34393a1d73a41febf4a048"

inherit pypi
inherit native
inherit setuptools3
