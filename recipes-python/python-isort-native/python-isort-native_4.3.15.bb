inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "11bcc819cca8812e2a3c6cbfe4a7bfef"
SRC_URI[sha256sum] = "96151fca2c6e736503981896495d344781b60d18bfda78dc11b290c6125ebdb6"

