inherit setuptools3
require python-isort-native.inc

SRC_URI[md5sum] = "e29d83726191c23a9d1e8310bd278ecd"
SRC_URI[sha256sum] = "c40744b6bc5162bbb39c1257fe298b7a393861d50978b565f3ccd9cb9de0182a"
