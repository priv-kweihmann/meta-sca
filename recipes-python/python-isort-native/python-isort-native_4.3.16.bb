inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "d3f18f7bacf9f29d9baee506ab8c5a1a"
SRC_URI[sha256sum] = "08f8e3f0f0b7249e9fad7e5c41e2113aba44969798a26452ee790c06f155d4ec"

