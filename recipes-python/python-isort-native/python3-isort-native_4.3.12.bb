inherit setuptools3
require python-isort-native.inc

SRC_URI[md5sum] = "085ba6b4c7c8685f034cabbf8e47167d"
SRC_URI[sha256sum] = "89041186651a9a6159683098f337eed0994d9d94e006f891c6e8cbeb8e65f1c7"
