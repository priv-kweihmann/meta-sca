inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "eae4cf28c20294170606f7f26365160c"
SRC_URI[sha256sum] = "268067462aed7eb2a1e237fcb287852f22077de3fb07964e87e00f829eea2d1a"

