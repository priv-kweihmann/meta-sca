inherit setuptools3
require python-isort-native.inc

SRC_URI[md5sum] = "05d66f2eb7ce2c2d702e86bac24bf9e4"
SRC_URI[sha256sum] = "54da7e92468955c4fceacd0c86bd0ec997b0e1ee80d97f67c35a78b719dccab1"
