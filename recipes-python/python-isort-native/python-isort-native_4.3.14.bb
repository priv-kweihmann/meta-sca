inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "d70ca39e5093426e8352c7a7e31ada28"
SRC_URI[sha256sum] = "473c458f279f1545fe80a4c901fe83681c27fb6969ae0bd2f1472143fc46eb1f"

