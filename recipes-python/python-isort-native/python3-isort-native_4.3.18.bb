inherit setuptools3
require python-isort-native.inc

SRC_URI[md5sum] = "00ac27b95c64e0266d7324565447041f"
SRC_URI[sha256sum] = "f09911f6eb114e5592abe635aded8bf3d2c3144ebcfcaf81ee32e7af7b7d1870"
