inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "f17a04e9697fed98e652f23fdeca2c2d"
SRC_URI[sha256sum] = "abbb2684aa234d5eb8a67ef36d4aa62ea080d46c2eba36ad09e2990ae52e4305"
