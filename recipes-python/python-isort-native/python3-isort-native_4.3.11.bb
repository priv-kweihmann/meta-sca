inherit setuptools3
require python-isort-native.inc

SRC_URI[md5sum] = "bb06686483856de4ab3d10a711fe97f2"
SRC_URI[sha256sum] = "909141ae3ac8c78daa9a6ae61371ad6daa628f533f6d3e01e5a0d073864ef26b"
