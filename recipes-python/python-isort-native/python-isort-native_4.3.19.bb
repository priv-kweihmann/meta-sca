inherit setuptools
require python-isort-native.inc

SRC_URI[md5sum] = "9d7d4981e2d5bc905627d25c7aa0a86b"
SRC_URI[sha256sum] = "49293e2ff590cc8d48bc1f51970548b5b102bf038439ca1af77f352164725628"
