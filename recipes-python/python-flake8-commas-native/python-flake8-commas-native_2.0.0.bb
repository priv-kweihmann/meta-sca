inherit setuptools
require python-flake8-commas-native.inc
