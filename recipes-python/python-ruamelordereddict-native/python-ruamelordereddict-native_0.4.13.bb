inherit setuptools
require python-ruamelordereddict-native.inc

SRC_URI[md5sum] = "06db93e19a27b2121c4c684216b9e3b7"
SRC_URI[sha256sum] = "bf0a198c8ce5d973c24e5dba12d3abc254996788ca6ad8448eabc6aa710db149"
