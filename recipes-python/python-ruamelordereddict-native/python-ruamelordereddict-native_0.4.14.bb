inherit setuptools
require python-ruamelordereddict-native.inc

SRC_URI[md5sum] = "e0723a39e81fdf5d986d892dc5a94bb8"
SRC_URI[sha256sum] = "281051d26eb2b18ef3d920e1e260716a52bd058a6b1a2f324102fc6a15cb8d4a"
