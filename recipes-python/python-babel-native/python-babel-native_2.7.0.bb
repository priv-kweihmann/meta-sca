inherit setuptools
require python-babel-native.inc

SRC_URI[md5sum] = "83c158b7dae9135750a7cf204e6e2eea"
SRC_URI[sha256sum] = "e86135ae101e31e2c8ec20a4e0c5220f4eed12487d5cf3f78be7e98d3a57fc28"
