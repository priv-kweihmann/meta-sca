
SUMMARY = "Data-Driven Tests for Python Unittest"
HOMEPAGE = "https://github.com/datadriventests/ddt"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=31d3abdb5983f06c0f7c19f4b9f61830"

PYPI_PACKAGE = "ddt"

SRC_URI[md5sum] = "434e1caadec0c9c5d97e611f6599ee8b"
SRC_URI[sha256sum] = "ef9e554b03241f8f8a1bbde5f749a199871d227335fe4bb320feb0abe6fbab00"

inherit pypi
inherit setuptools3
inherit native
