inherit setuptools3
require python-ddt-native.inc

SRC_URI[md5sum] = "1270d706454088ea108f23fbaa800e56"
SRC_URI[sha256sum] = "d13e6af8f36238e89d00f4ebccf2bda4f6d1878be560a6600689e42077e164e3"