inherit setuptools3
require python-flake8-bugbear-native.inc

SRC_URI[md5sum] = "98b3b558999cd42418823e8fa39b948a"
SRC_URI[sha256sum] = "5070774b668be92c4312e5ca82748ddf4ecaa7a24ff062662681bb745c7896eb"
