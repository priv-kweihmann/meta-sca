inherit setuptools
require python-anytree-native.inc

SRC_URI[md5sum] = "6ba851f5b0ddcad0cc499baad7aea084"
SRC_URI[sha256sum] = "a221b6a603c3a5d5e417894dc48eaa8b1eab04056e1f5bb509bcfff0e7a47883"
