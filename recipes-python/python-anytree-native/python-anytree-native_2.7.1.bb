inherit setuptools
require python-anytree-native.inc
