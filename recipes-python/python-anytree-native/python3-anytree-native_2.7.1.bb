inherit setuptools3
require python-anytree-native.inc
