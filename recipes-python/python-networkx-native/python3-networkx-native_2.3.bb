inherit setuptools3
require python-networkx-native.inc

SRC_URI[md5sum] = "320d3f6c7872732baa63cedafddadea9"
SRC_URI[sha256sum] = "8311ddef63cf5c5c5e7c1d0212dd141d9a1fe3f474915281b73597ed5f1d4e3d"

