SUMMARY = "Better living through Python with decorators"

HOMEPAGE = "https://github.com/micheles/decorator"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=be2fd2007972bf96c08af3293d728b22"

PYPI_PACKAGE = "decorator"

inherit pypi
inherit setuptools3
inherit native

SRC_URI[md5sum] = "933981f288c4230816b5beee8d40e6ea"
SRC_URI[sha256sum] = "54c38050039232e1db4ad7375cfce6748d7b41c29e95a081c8a6d2c30364a2ce"
