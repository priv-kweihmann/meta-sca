SUMMARY = "Better living through Python with decorators"

HOMEPAGE = "https://github.com/micheles/decorator"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=be2fd2007972bf96c08af3293d728b22"

PYPI_PACKAGE = "decorator"

inherit pypi
inherit setuptools3
inherit native

SRC_URI[md5sum] = "d83c624cce93e6bdfab144821b526e1d"
SRC_URI[sha256sum] = "e3a62f0520172440ca0dcc823749319382e377f37f140a0b99ef45fecb84bfe7"
