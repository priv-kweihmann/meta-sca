SUMMARY = "Better living through Python with decorators"
HOMEPAGE = "https://github.com/micheles/decorator"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=be2fd2007972bf96c08af3293d728b22"

PYPI_PACKAGE = "decorator"

SRC_URI[md5sum] = "769d96549a076f6bdcf0c730797f58f1"
SRC_URI[sha256sum] = "acda948ffcfe4bd0c4a57834b74ad968b91925b8201b740ca9d46fb8c5c618ce"

inherit pypi
inherit setuptools3
inherit native
