SUMMARY = "Better living through Python with decorators"
HOMEPAGE = "https://github.com/micheles/decorator"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=be2fd2007972bf96c08af3293d728b22"

PYPI_PACKAGE = "decorator"

SRC_URI[md5sum] = "c35b2a3446478986e91b15ad1626e152"
SRC_URI[sha256sum] = "6f201a6c4dac3d187352661f508b9364ec8091217442c9478f1f83c003a0f060"

inherit pypi
inherit setuptools3
inherit native
