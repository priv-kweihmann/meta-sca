SUMMARY = "Better living through Python with decorators"
HOMEPAGE = "https://github.com/micheles/decorator"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=be2fd2007972bf96c08af3293d728b22"

PYPI_PACKAGE = "decorator"

SRC_URI[md5sum] = "e5fe4d04e737af2a2ac95b524d509dd9"
SRC_URI[sha256sum] = "f2e71efb39412bfd23d878e896a51b07744f2e2250b2e87d158e76828c5ae202"

inherit pypi
inherit setuptools3
inherit native
