inherit setuptools3
require pytest-runner-native.inc