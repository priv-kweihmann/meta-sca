inherit setuptools3
require pytest-runner.inc