inherit setuptools
require python-capstone-native.inc

SRC_URI[md5sum] = "250e3b5fbb9d6a2472bbf5eab4842189"
SRC_URI[sha256sum] = "5857accc0de1e769b0ec0a0ca985715bfa96e5a66a2ebb3aaed43a8e3655377f"
