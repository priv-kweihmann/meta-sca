inherit setuptools
require python-dparse-native.inc

SRC_URI[md5sum] = "4e3dc79fbc8f58a7b8dd1ca3744cc1b0"
SRC_URI[sha256sum] = "00a5fdfa900629e5159bf3600d44905b333f4059a3366f28e0dbd13eeab17b19"
