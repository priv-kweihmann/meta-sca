inherit setuptools
require python-gitpython-native.inc

SRC_URI[md5sum] = "cee43a39a1468084d49d1c49fb675204"
SRC_URI[sha256sum] = "8237dc5bfd6f1366abeee5624111b9d6879393d84745a507de0fda86043b65a8"
