inherit setuptools
require python-pyyaml-native.inc

SRC_URI[md5sum] = "b78b96636d68ac581c0e2f38158c224f"
SRC_URI[sha256sum] = "3ef3092145e9b70e3ddd2c7ad59bdd0252a94dfe3949721633e41344de00a6bf"
