inherit setuptools
require python-flake8-bandit-native.inc

SRC_URI[md5sum] = "bb5af23f4595d3c7840f7f9727aae1c2"
SRC_URI[sha256sum] = "52a67f453ba765398098b39a2273e138983b3499465ef39a12e8ee544c4598fc"
