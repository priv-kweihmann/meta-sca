inherit setuptools3
require python-flake8-quotes-native.inc

SRC_URI[md5sum] = "0726706faee86e9ec8321ea40096d986"
SRC_URI[sha256sum] = "10c9af6b472d4302a8e721c5260856c3f985c5c082b04841aefd2f808ac02038"
