SUMMARY = "Parsing ELF and DWARF in Python"
DESCRIPTION = "Parsing ELF and DWARF in Python"
HOMEPAGE = "https://github.com/eliben/pyelftools"
LICENSE = "PYELFTOOLS"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5ce2a2b07fca326bc7c146d10105ccfc"

PYPI_PACKAGE = "pyelftools"

inherit pypi
inherit setuptools3
inherit native

SRC_URI[md5sum] = "0ba0de4b47127249c4d632ae299cb0e8"
SRC_URI[sha256sum] = "86ac6cee19f6c945e8dedf78c6ee74f1112bd14da5a658d8c9d4103aed5756a2"
