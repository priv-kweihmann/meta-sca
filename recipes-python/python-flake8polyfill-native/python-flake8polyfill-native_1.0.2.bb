inherit setuptools
require python-flake8polyfill-native.inc

SRC_URI[md5sum] = "076110bed47814d27019a0db25ad481b"
SRC_URI[sha256sum] = "e44b087597f6da52ec6393a709e7108b2905317d0c0b744cdca6208e670d8eda"
