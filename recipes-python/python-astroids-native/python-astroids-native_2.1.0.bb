inherit setuptools
require python-astroids-native.inc

SRC_URI[md5sum] = "09277b4400fc18a22d4bfc45b50c4448"
SRC_URI[sha256sum] = "35b032003d6a863f5dcd7ec11abd5cd5893428beaa31ab164982403bcb311f22"
