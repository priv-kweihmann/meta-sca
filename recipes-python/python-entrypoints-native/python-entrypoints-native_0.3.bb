inherit setuptools
require python-entrypoints-native.inc

SRC_URI[md5sum] = "c5c61ea2e46a0c50ea08f4af7955a0b1"
SRC_URI[sha256sum] = "c70dd71abe5a8c85e55e12c19bd91ccfeec11a6e99044204511f9ed547d48451"
