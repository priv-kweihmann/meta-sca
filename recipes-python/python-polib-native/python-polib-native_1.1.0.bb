inherit setuptools
require python-polib-native.inc

SRC_URI[md5sum] = "eeedc0f1e8f2dbfbb6192772d02795e0"
SRC_URI[sha256sum] = "fad87d13696127ffb27ea0882d6182f1a9cf8a5e2b37a587751166c51e5a332a"
