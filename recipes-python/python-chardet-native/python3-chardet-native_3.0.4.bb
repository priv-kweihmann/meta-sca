DESCRIPTION = "Python 2/3 compatible character encoding detector."
HOMEPAGE = "https://github.com/chardet/chardet"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6f89e2100d9b6cdffcea4f398e37343"
LICENSE = "LGPL-2.1"

PYPI_PACKAGE = "chardet"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "7dd1ba7f9c77e32351b0a0cfacf4055c"
SRC_URI[sha256sum] = "84ab92ed1c4d4f16916e05906b6b75a6c0fb5db821cc65e70cbd64a3e2a5eaae"
