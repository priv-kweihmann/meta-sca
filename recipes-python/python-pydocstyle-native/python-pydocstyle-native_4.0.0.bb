inherit setuptools
require python-pydocstyle-native.inc

DEPENDS += "${PYTHON_PN}-configparser-native"
