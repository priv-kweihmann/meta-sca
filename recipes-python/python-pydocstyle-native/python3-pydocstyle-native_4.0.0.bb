inherit setuptools3
require python-pydocstyle-native.inc
