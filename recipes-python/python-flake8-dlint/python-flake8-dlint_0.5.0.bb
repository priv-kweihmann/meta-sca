inherit setuptools
require python-flake8-dlint.inc
