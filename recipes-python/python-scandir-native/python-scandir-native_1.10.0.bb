inherit setuptools
require python-scandir-native.inc

SRC_URI[md5sum] = "f8378f4d9f95a6a78e97ab01aa900c1d"
SRC_URI[sha256sum] = "4d4631f6062e658e9007ab3149a9b914f3548cb38bfb021c64f39a025ce578ae"
