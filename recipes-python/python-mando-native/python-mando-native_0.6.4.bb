inherit setuptools
require python-mando-native.inc

SRC_URI[md5sum] = "50e377ef9fe89415c1fc8ea98adde1af"
SRC_URI[sha256sum] = "79feb19dc0f097daa64a1243db578e7674909b75f88ac2220f1c065c10a0d960"
