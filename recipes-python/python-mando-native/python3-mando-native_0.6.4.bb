SUMMARY = "Create Python CLI apps with little to no effort at all! "
HOMEPAGE = "https://github.com/rubik/mando"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a3c8e41bdf640795815537c1ce89a3aa"

PYPI_PACKAGE = "mando"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "50e377ef9fe89415c1fc8ea98adde1af"
SRC_URI[sha256sum] = "79feb19dc0f097daa64a1243db578e7674909b75f88ac2220f1c065c10a0d960"
