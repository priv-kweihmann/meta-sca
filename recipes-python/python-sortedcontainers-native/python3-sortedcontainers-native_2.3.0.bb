SUMMARY = "Sorted Containers -- Sorted List, Sorted Dict, Sorted Set"
HOMEPAGE = "https://github.com/grantjenks/python-sortedcontainers"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7c7c6a1a12ec816da16c1839137d53ae"

PYPI_PACKAGE = "sortedcontainers"

SRC_URI[md5sum] = "660260df593a3769c7b5854f13d574c0"
SRC_URI[sha256sum] = "59cc937650cf60d677c16775597c89a960658a09cf7c1a668f86e1e4464b10a1"

inherit pypi
inherit setuptools3
inherit native
