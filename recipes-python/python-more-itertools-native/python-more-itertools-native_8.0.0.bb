inherit setuptools
require python-more-itertools-native.inc

SRC_URI[md5sum] = "3af998eb1233454da823d936da17d84f"
SRC_URI[sha256sum] = "53ff73f186307d9c8ef17a9600309154a6ae27f25579e80af4db8f047ba14bc2"
