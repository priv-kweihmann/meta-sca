inherit setuptools
require python-more-itertools-native.inc

SRC_URI[md5sum] = "2c9289351271e65fea093c7657e4de7e"
SRC_URI[sha256sum] = "8bb43d1f51ecef60d81854af61a3a880555a14643691cc4b64a6ee269c78f09a"
