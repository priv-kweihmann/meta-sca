inherit setuptools
require python-more-itertools-native.inc

SRC_URI[md5sum] = "fb155c9e876ae8e20bff89c9d519776f"
SRC_URI[sha256sum] = "b84b238cce0d9adad5ed87e745778d20a3f8487d0f0cb8b8a586816c7496458d"
