inherit setuptools
require python-pathspec-native.inc

SRC_URI[md5sum] = "d76bc12293518c652e1c2b7fb028529e"
SRC_URI[sha256sum] = "54a5eab895d89f342b52ba2bffe70930ef9f8d96e398cccf530d21fa0516a873"
