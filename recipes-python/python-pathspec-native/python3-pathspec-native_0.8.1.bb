SUMMARY = "Utility library for gitignore style pattern matching of file paths"
HOMEPAGE = "https://github.com/cpburnz/python-path-specification"

LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=815ca599c9df247a0c7f619bab123dad"

PYPI_PACKAGE = "pathspec"

SRC_URI[md5sum] = "fbd6575abb2be29927aebb2f38110bb6"
SRC_URI[sha256sum] = "86379d6b86d75816baba717e64b1a3a3469deb93bb76d613c9ce79edc5cb68fd"

inherit pypi
inherit setuptools3
inherit native
