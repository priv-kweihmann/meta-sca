SUMMARY = "Utility library for gitignore style pattern matching of file paths. "
DESCRIPTION = "Utility library for gitignore style pattern matching of file paths. "
HOMEPAGE = "https://github.com/cpburnz/python-path-specification"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=815ca599c9df247a0c7f619bab123dad"

PYPI_PACKAGE = "pathspec"

inherit pypi
inherit setuptools3
inherit native

SRC_URI[md5sum] = "2707d52136575dd8e1c5b0984990f365"
SRC_URI[sha256sum] = "562aa70af2e0d434367d9790ad37aed893de47f1693e4201fd1d3dca15d19b96"
