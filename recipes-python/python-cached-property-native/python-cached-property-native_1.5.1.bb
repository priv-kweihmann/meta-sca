inherit setuptools
require python-cached-property-native.inc

SRC_URI[md5sum] = "4b6f3cd429da5f487f4ebf3242bb991f"
SRC_URI[sha256sum] = "9217a59f14a5682da7c4b8829deadbfc194ac22e9908ccf7c8820234e80a1504"
