SUMMARY = "A decorator for caching properties in classes"
HOMEPAGE = "https://github.com/pydanny/cached-property"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=db7ff60c4e14f58534201242803d8abc"

PYPI_PACKAGE = "cached-property"

SRC_URI[md5sum] = "3451c63f8733ea0756ca1dd2b0c04bb8"
SRC_URI[sha256sum] = "9fa5755838eecbb2d234c3aa390bd80fbd3ac6b6869109bfc1b499f7bd89a130"

inherit pypi
inherit setuptools3
inherit native
