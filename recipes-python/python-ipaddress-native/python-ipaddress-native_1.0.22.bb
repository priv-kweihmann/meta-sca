inherit setuptools
require python-ipaddress-native.inc

SRC_URI[md5sum] = "74c1ce3109f30eaa1ab3dd342e7b76d4"
SRC_URI[sha256sum] = "b146c751ea45cad6188dd6cf2d9b757f6f4f8d6ffb96a023e6f2e26eea02a72c"
