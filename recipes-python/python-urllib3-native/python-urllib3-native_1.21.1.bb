inherit setuptools
require python-urllib3-native.inc

SRC_URI[md5sum] = "ef6c72c79b9c6bcd68c204f9b92abc86"
SRC_URI[sha256sum] = "b14486978518ca0901a76ba973d7821047409d7f726f22156b24e83fd71382a5"
