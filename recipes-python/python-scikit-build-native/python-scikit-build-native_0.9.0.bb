inherit setuptools
require python-scikit-build-native.inc

SRC_URI[md5sum] = "f31032ffb30313ddbc5b4329ebe2e0e6"
SRC_URI[sha256sum] = "81119231cd9c4eba7acc1aaf7351a33b69494c2ccf94a31c2902a80622f089a9"

