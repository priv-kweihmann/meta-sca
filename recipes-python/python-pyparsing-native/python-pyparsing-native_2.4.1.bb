inherit setuptools
require python-pyparsing-native.inc

SRC_URI[md5sum] = "482a1a7ab602d4817529d23deb1cd4dc"
SRC_URI[sha256sum] = "530d8bf8cc93a34019d08142593cf4d78a05c890da8cf87ffa3120af53772238"
