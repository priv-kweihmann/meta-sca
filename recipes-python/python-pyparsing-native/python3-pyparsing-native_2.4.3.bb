inherit setuptools3
require python-pyparsing-native.inc
