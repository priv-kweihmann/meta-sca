inherit setuptools
require python-pyparsing-native.inc

SRC_URI[md5sum] = "46d02cbe0461fe0571d51649e6006ef5"
SRC_URI[sha256sum] = "6f98a7b9397e206d78cc01df10131398f1c8b8510a2f4d97d9abd82e1aacdd80"
