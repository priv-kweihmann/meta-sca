inherit setuptools3
require python-pyparsing-native.inc

SRC_URI[md5sum] = "e534c0ca755155823bf45fdd8d084922"
SRC_URI[sha256sum] = "1873c03321fc118f4e9746baf201ff990ceb915f433f23b395f5580d1840cb2a"
