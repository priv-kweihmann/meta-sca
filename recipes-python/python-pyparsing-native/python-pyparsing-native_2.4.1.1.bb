inherit setuptools
require python-pyparsing-native.inc

SRC_URI[md5sum] = "1ef83d1f56243376a461593a7dfb12a2"
SRC_URI[sha256sum] = "d6c5ffe9d0305b9b977f7a642d36b9370954d1da7ada4c62393382cbadad4265"
