inherit setuptools
require python-pyparsing-native.inc
