inherit setuptools3
require python-pyparsing-native.inc

SRC_URI[md5sum] = "630e86b719619a251de0ba4a97239cec"
SRC_URI[sha256sum] = "66c9268862641abcac4a96ba74506e594c884e3f57690a696d21ad8210ed667a"
