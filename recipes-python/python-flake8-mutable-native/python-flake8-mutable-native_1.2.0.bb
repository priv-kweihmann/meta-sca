inherit setuptools
require python-flake8-mutable-native.inc

SRC_URI[md5sum] = "5976fbe6c578d8c43ba1a8c372bdc3a5"
SRC_URI[sha256sum] = "ee9b77111b867d845177bbc289d87d541445ffcc6029a0c5c65865b42b18c6a6"
