inherit setuptools3
require python-wemake-python-styleguide-native.inc

SRC_URI[md5sum] = "0b6643b66c7e4d63fa16057ad8571e63"
SRC_URI[sha256sum] = "5a25f6d877000cc6d657438a94474f44db6563adba3a518d75d6e17d8017cc4f"
