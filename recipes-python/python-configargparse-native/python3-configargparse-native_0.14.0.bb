inherit setuptools3
require python-configargparse-native.inc

SRC_URI[md5sum] = "61dd2adf697007db19a57aa00fa6388c"
SRC_URI[sha256sum] = "2e2efe2be3f90577aca9415e32cb629aa2ecd92078adbe27b53a03e53ff12e91"
