inherit setuptools3
require python-configargparse-native.inc

SRC_URI[md5sum] = "aba15b7973b7a70bea86fd69289f8fe3"
SRC_URI[sha256sum] = "baaf0fd2c1c108d007f402dab5481ac5f12d77d034825bf5a27f8224757bd0ac"
