inherit setuptools
require python-pytest-native.inc

SRC_URI[md5sum] = "662313b4f539f5b66d2fb77791458e82"
SRC_URI[sha256sum] = "c3d5020755f70c82eceda3feaf556af9a341334414a8eca521a18f463bcead88"
