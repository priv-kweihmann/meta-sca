inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "90fec5504fcebc5d1081bcd654df7cf0"
SRC_URI[sha256sum] = "b78fe2881323bd44fd9bd76e5317173d4316577e7b1cddebae9136a4495ec865"
