inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "79efe2708aa73dd5c618e5a89d80ce58"
SRC_URI[sha256sum] = "cc6620b96bc667a0c8d4fa592a8c9c94178a1bd6cc799dbb057dfd9286d31a31"
