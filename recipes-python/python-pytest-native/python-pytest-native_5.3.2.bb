inherit setuptools
require python-pytest-native.inc

SRC_URI[md5sum] = "71a8eb2ab5efb76512d9a69bd6477034"
SRC_URI[sha256sum] = "6b571215b5a790f9b41f19f3531c53a45cf6bb8ef2988bc1ff9afb38270b25fa"
