inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "06cdb939a1f45f6b82b304abb87c3e30"
SRC_URI[sha256sum] = "f67403f33b2b1d25a6756184077394167fe5e2f9d8bdaab30707d19ccec35427"
