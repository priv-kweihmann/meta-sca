inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "c8c8c42e168d279be43ba91d90fefda9"
SRC_URI[sha256sum] = "3805d095f1ea279b9870c3eeae5dddf8a81b10952c8835cd628cf1875b0ef031"
