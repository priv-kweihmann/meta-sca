inherit setuptools
require python-pytest-native.inc

SRC_URI[md5sum] = "00561d0295aab167987f8a4f784964c4"
SRC_URI[sha256sum] = "ca563435f4941d0cb34767301c27bc65c510cb82e90b9ecf9cb52dc2c63caaa0"
