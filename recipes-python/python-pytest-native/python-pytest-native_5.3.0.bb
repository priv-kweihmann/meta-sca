inherit setuptools
require python-pytest-native.inc

SRC_URI[md5sum] = "4c30a07f56c37d9b0e0641048c667696"
SRC_URI[sha256sum] = "1897d74f60a5d8be02e06d708b41bf2445da2ee777066bd68edf14474fc201eb"
