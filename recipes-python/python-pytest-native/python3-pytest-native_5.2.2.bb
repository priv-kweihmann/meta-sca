inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "889344299c9182aff67d6e461cb7af29"
SRC_URI[sha256sum] = "27abc3fef618a01bebb1f0d6d303d2816a99aa87a5968ebc32fe971be91eb1e6"
