inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "e4f258bc9220828385e4ef8620904882"
SRC_URI[sha256sum] = "6ef6d06de77ce2961156013e9dff62f1b2688aa04d0dc244299fe7d67e09370d"
