inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "21c34b9eebd120883552116be32b0211"
SRC_URI[sha256sum] = "ff0090819f669aaa0284d0f4aad1a6d9d67a6efdc6dd4eb4ac56b704f890a0d6"
