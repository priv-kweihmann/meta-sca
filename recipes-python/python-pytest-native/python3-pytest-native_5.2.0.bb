inherit setuptools3
require python-pytest-native.inc

SRC_URI[md5sum] = "ec66affcfd8d6a082743cebdee98c593"
SRC_URI[sha256sum] = "d8ba7be9466f55ef96ba203fc0f90d0cf212f2f927e69186e1353e30bc7f62e5"
