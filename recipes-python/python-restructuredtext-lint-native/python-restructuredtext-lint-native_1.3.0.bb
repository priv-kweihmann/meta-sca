inherit setuptools
require python-restructuredtext-lint-native.inc

SRC_URI[md5sum] = "0f90ef86ca94b1389eccf5faccaebef4"
SRC_URI[sha256sum] = "97b3da356d5b3a8514d8f1f9098febd8b41463bed6a1d9f126cf0a048b6fd908"
