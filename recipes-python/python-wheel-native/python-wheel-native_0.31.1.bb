inherit setuptools
require python-wheel-native.inc

SRC_URI[md5sum] = "0ac15797d94ca759702b1d52425850c4"
SRC_URI[sha256sum] = "0a2e54558a0628f2145d2fc822137e322412115173e8a2ddbe1c9024338ae83c"

