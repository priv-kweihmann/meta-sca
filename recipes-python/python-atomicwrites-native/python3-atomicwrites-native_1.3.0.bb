inherit setuptools3
require python-atomicwrites-native.inc

SRC_URI[md5sum] = "ce11f780a4ce0fce8a55d64494a88178"
SRC_URI[sha256sum] = "75a9445bac02d8d058d5e1fe689654ba5a6556a1dfd8ce6ec55a0ed79866cfa6"
