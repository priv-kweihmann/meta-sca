inherit setuptools
require python-flake8-print-native.inc
