inherit setuptools3
require python-flake8-print-native.inc
