inherit setuptools3
require python-pylazy-object-proxy-native.inc

SRC_URI[md5sum] = "e128152b76eb5b9ba759504936139fd0"
SRC_URI[sha256sum] = "eb91be369f945f10d3a49f5f9be8b3d0b93a4c2be8f8a5b83b0571b8123e0a7a"
