inherit setuptools
require python-flake8-annotations-complexity-native.inc
