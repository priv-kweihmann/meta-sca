inherit setuptools
require python-jsonmerge-native.inc

SRC_URI[md5sum] = "adf870b2464d40e1db280946236a9083"
SRC_URI[sha256sum] = "c05229545d55c1bbfdb3fa11c7f8a1c9868c713af209059ac48e7d86fa9c6a1f"
