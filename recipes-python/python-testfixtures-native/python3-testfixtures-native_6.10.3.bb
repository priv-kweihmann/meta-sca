SUMMARY = "testfixtures is a collection of helpers and mock objects that are useful when writing automated tests in Python"

HOMEPAGE = "https://github.com/Simplistix/testfixtures"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=77b3c56f6b4bca98e817b4d46f6b5805"

PYPI_PACKAGE = "testfixtures"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "21235b9eb94e428fd580ff3e8085fa74"
SRC_URI[sha256sum] = "8f22100d4fb841b958f64e71c8820a32dc46f57d4d7e077777b932acd87b7327"
