SUMMARY = "testfixtures is a collection of helpers and mock objects that are useful when writing automated tests in Python"

HOMEPAGE = "https://github.com/Simplistix/testfixtures"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=77b3c56f6b4bca98e817b4d46f6b5805"

PYPI_PACKAGE = "testfixtures"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "af462c73e6705a1fecb069eb7e7d0a2f"
SRC_URI[sha256sum] = "1ef5c8e57b75883593b21c9bd9bd5a5ce7bbd852fc71486dd3c6b913b697b046"
