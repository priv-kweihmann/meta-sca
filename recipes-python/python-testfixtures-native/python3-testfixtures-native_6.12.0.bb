SUMMARY = "testfixtures is a collection of helpers and mock objects that are useful when writing automated tests in Python"

HOMEPAGE = "https://github.com/Simplistix/testfixtures"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=77b3c56f6b4bca98e817b4d46f6b5805"

PYPI_PACKAGE = "testfixtures"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "571c542cacbb55919961eac6dd41220f"
SRC_URI[sha256sum] = "c352760016f0e5579a3e5565387e6d582ccad4db9791b6a293fdfc59d4591b97"
