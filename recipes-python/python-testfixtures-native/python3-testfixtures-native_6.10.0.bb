SUMMARY = "testfixtures is a collection of helpers and mock objects that are useful when writing automated tests in Python"

HOMEPAGE = "https://github.com/Simplistix/testfixtures"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=77b3c56f6b4bca98e817b4d46f6b5805"

PYPI_PACKAGE = "testfixtures"

inherit pypi
inherit native
inherit setuptools3

SRC_URI[md5sum] = "892120685d09d61addb2b0a35581e42b"
SRC_URI[sha256sum] = "9d230c5c80746f9f86a16a1f751a5cf5d8e317d4cc48243a19fb180d22303bce"
