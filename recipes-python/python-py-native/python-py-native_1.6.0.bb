inherit pypi setuptools
require python-py-native.inc

SRC_URI[md5sum] = "5ccd0cd5373c55171cf9fd61b9f19a1b"
SRC_URI[sha256sum] = "06a30435d058473046be836d3fc4f27167fd84c45b99704f2fb5509ef61f9af1"