inherit setuptools3
require python-flake8-dlint-native.inc
