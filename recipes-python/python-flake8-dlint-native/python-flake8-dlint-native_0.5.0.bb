inherit setuptools
require python-flake8-dlint-native.inc
