SUMMARY = "The Real First Universal Charset Detector"
HOMEPAGE = "https://github.com/ousret/charset_normalizer"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0974a390827087287db39928f7c524b5"

PYPI_PACKAGE = "charset-normalizer"

SRC_URI[sha256sum] = "f23667ebe1084be45f6ae0538e4a5a865206544097e4e8bbcacf42cd02a348f3"

inherit pypi
inherit setuptools3
inherit native
