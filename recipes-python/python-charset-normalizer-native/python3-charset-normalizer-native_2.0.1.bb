SUMMARY = "The Real First Universal Charset Detector"
HOMEPAGE = "https://github.com/ousret/charset_normalizer"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0974a390827087287db39928f7c524b5"

PYPI_PACKAGE = "charset-normalizer"

SRC_URI[sha256sum] = "ad0da505736fc7e716a8da15bf19a985db21ac6415c26b34d2fafd3beb3d927e"

inherit pypi
inherit setuptools3
inherit native
