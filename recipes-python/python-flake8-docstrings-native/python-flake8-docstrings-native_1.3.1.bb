inherit setuptools
require python-flake8-docstrings-native.inc

SRC_URI[md5sum] = "f77262658691809f6dbcd6ba9deb6a35"
SRC_URI[sha256sum] = "d8d72ccd5807c1ab9ff1466cb9bece0c4d94b8669e9bc4f472abc80dbc5d399e"
