inherit setuptools
require python-contextlib2-native.inc

SRC_URI[md5sum] = "95fe420941ebc64951cd9d89edc41870"
SRC_URI[sha256sum] = "509f9419ee91cdd00ba34443217d5ca51f5a364a404e1dce9e8979cea969ca48"
