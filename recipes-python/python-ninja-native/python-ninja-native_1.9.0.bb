inherit setuptools
require python-ninja-native.inc

NINJA_BINNAME= "ninja2"

SRC_URI[md5sum] = "09bd59d6a4ce5787ee148e4fa0fbef4a"
SRC_URI[sha256sum] = "78c840ef1c94507956dac8810282cade2b139f0fda44c2f4706522415b990816"

