
inherit setuptools3
require python-setuptools-scm-native.inc
