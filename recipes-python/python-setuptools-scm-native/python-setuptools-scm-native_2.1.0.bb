inherit setuptools
require python-setuptools-scm-native.inc

SRC_URI[md5sum] = "cfec5d2dbbd0a85c40066f79035b5878"
SRC_URI[sha256sum] = "a767141fecdab1c0b3c8e4c788ac912d7c94a0d6c452d40777ba84f918316379"
