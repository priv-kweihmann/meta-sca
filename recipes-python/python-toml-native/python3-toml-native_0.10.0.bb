inherit setuptools3
require python-toml-native.inc

SRC_URI[md5sum] = "63fffbe2d632865ec29cd69bfdf36682"
SRC_URI[sha256sum] = "229f81c57791a41d65e399fc06bf0848bab550a9dfd5ed66df18ce5f05e73d5c"
