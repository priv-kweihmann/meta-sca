inherit setuptools
require python-functools32-native.inc

SRC_URI[md5sum] = "09f24ffd9af9f6cd0f63cb9f4e23d4b2"
SRC_URI[sha256sum] = "f6253dfbe0538ad2e387bd8fdfd9293c925d63553f5813c4e587745416501e6d"
