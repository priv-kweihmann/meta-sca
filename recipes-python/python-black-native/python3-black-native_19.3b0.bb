inherit setuptools3
require python-black-native.inc

SRC_URI[md5sum] = "0a84ec80ca88408e83e0a904a674d677"
SRC_URI[sha256sum] = "68950ffd4d9169716bcb8719a56c07a2f4485354fec061cdd5910aa07369731c"
