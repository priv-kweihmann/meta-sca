inherit setuptools
require python-typing-native.inc

SRC_URI[md5sum] = "8a3e4b822bac02b9b33c97e7d4f1521c"
SRC_URI[sha256sum] = "53765ec4f83a2b720214727e319607879fec4acde22c4fbb54fa2604e79e44ce"
