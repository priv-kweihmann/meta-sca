SUMMARY = "Persistent/Immutable/Functional data structures for Python"
HOMEPAGE = "https://github.com/tobgu/pyrsistent"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENCE.mit;md5=ca574f2891cf528b3e7a2ee570337e7c"

PYPI_PACKAGE = "pyrsistent"

SRC_URI[md5sum] = "e40a7824a3bad4834e0c04035c7f6c45"
SRC_URI[sha256sum] = "27515d2d5db0629c7dadf6fbe76973eb56f098c1b01d36de42eb69220d2c19e4"

inherit pypi
inherit setuptools3
inherit native
