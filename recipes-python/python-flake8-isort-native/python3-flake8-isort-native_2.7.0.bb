inherit setuptools3
require python-flake8-isort-native.inc
