inherit setuptools
require python-flake8-isort-native.inc
