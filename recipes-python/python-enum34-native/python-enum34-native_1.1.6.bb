inherit setuptools
require python-enum34-native.inc

SRC_URI[md5sum] = "5f13a0841a61f7fc295c514490d120d0"
SRC_URI[sha256sum] = "8ad8c4783bf61ded74527bffb48ed9b54166685e4230386a9ed9b1279e2df5b1"
