inherit setuptools
require python-requests-native.inc

SRC_URI[md5sum] = "1f33ee336999c654adad28b152e4c3b7"
SRC_URI[sha256sum] = "f7685b2d620a172053cced288dddf12d4b3441a382cc382821c0f36c02488516"
