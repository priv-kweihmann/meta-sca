inherit sca
SCA_AVAILABLE_MODULES = "msgcheck"