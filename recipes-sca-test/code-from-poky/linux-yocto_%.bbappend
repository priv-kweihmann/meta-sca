##inherit sca

## Limit the modules to a reasonable amount
SCA_AVAILABLE_MODULES = " bashate \
                          bitbake \
                          checkbashism \
                          kconfighard \
                          "