inherit sca