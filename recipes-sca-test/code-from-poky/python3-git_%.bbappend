inherit sca
