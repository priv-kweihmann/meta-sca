SUMMARY = "NPM: @nodelib/fs.stat"
DESCRIPTION = "Get the status of a file with some features"


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=580f1c3c6765fecfdb93bdf4e068d952"

SRC_URI = "https://registry.npmjs.org/@nodelib/fs.stat/-/fs.stat-2.0.3.tgz"
SRC_URI[md5sum] = "3656d4c4c2e5653c1c307ee38bd874b2"
SRC_URI[sha256sum] = "8bc67e2b2878b044f7a573d12ee39a68019101a36acadea5926309b729f7fbfe"

NPM_PKGNAME = "@nodelib/fs.stat"

inherit npmhelper
inherit native
