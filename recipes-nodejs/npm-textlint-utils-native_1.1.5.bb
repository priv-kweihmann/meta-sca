SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.1.5.tgz"
SRC_URI[md5sum] = "7cab8792fad5f4bcc6b8db33bdd9ab2a"
SRC_URI[sha256sum] = "631986c44e956cd2c821e37c3a7598befffbabcbd7097fb68a928539dc865423"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
