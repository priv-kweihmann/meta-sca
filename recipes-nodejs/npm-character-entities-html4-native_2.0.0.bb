SUMMARY = "NPM: character-entities-html4"
DESCRIPTION = "HTML4 character entity information"
HOMEPAGE = "https://github.com/wooorm/character-entities-html4#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/character-entities-html4/-/character-entities-html4-2.0.0.tgz"
SRC_URI[md5sum] = "409dd272f47b569e83040c051646c3fe"
SRC_URI[sha256sum] = "8ca44bd9ad24f9a6115211f26b6722e05085c5b0793154c41f24bbd5777fefa2"

NPM_PKGNAME = "character-entities-html4"

inherit npmhelper
inherit native
