SUMMARY = "NPM: indexof"
DESCRIPTION = "Microsoft sucks"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://Readme.md;beginline=13;md5=9d658cc6f76bfa120652c598a5b558ea"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/indexof/-/indexof-0.0.1.tgz"
SRC_URI[md5sum] = "eb0285733250a99c7fcd9da73be83ecf"
SRC_URI[sha256sum] = "9c34ba36afcc7ae8a40bece80885a306ae85b70c7abba786f856b2e501db2817"

NPM_PKGNAME = "indexof"

inherit npmhelper
inherit native
