SUMMARY = "NPM: @getify/eslint-plugin-proper-arrows"
DESCRIPTION = "ESLint rules to ensure proper arrow function definitions"
HOMEPAGE = "https://github.com/getify/eslint-plugin-proper-arrows"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1d94c8e9d6efb6e3b31b75ff3c6fe905"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@getify/eslint-plugin-proper-arrows/-/eslint-plugin-proper-arrows-9.1.1.tgz"
SRC_URI[md5sum] = "90ac470c402d0ad701f18f6c528d7f03"
SRC_URI[sha256sum] = "c672564698b089723a3804f14ff12e925e9dba5ab5e86b27c6ea7c883e610756"

NPM_PKGNAME = "@getify/eslint-plugin-proper-arrows"

inherit npmhelper
inherit native
