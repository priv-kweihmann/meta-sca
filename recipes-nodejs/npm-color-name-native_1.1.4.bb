SUMMARY = "NPM: color-name"
DESCRIPTION = "A list of color names and its values"
HOMEPAGE = "https://github.com/colorjs/color-name"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d"

SRC_URI = "https://registry.npmjs.org/color-name/-/color-name-1.1.4.tgz"
SRC_URI[md5sum] = "a8d4412852471526b8027af2532d0d2b"
SRC_URI[sha256sum] = "507b7c4461e8eb941355af9a59e9a7e02cd0e7c6176b48d1809766344f3f1708"

NPM_PKGNAME = "color-name"

inherit npmhelper
inherit native
