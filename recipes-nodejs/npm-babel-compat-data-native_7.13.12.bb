SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.13.12.tgz"
SRC_URI[md5sum] = "64714ff179c6a525b547a5a9bccda9e5"
SRC_URI[sha256sum] = "8490db081f6965bc9d277f1094051a3c45b9ce24f3a987135fc3c5b68775c5cc"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
