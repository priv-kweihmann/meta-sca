SUMMARY = "NPM: character-entities-html4"
DESCRIPTION = "HTML4 character entity information"
HOMEPAGE = "https://github.com/wooorm/character-entities-html4#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/character-entities-html4/-/character-entities-html4-1.1.4.tgz"
SRC_URI[md5sum] = "acbd414e14353afb3b668b10cca4d884"
SRC_URI[sha256sum] = "5f3fb2dcdeff3b91765173e8c85df2cc820fe4ae0efca87ff48bfc0469a2ff46"

NPM_PKGNAME = "character-entities-html4"

inherit npmhelper
inherit native
