SUMMARY = "NPM: unist-util-position"
DESCRIPTION = "unist utility to get the position of a node"
HOMEPAGE = "https://github.com/syntax-tree/unist-util-position#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/unist-util-position/-/unist-util-position-4.0.1.tgz"
SRC_URI[md5sum] = "bb3895c1be7820f67a76d8be755e126c"
SRC_URI[sha256sum] = "863bc7adac9cd214ee46d25a9b4852402905330f1f092b59b09181a6b7105d13"

NPM_PKGNAME = "unist-util-position"

inherit npmhelper
inherit native
