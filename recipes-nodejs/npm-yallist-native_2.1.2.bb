SUMMARY = "NPM: yallist"
DESCRIPTION = "Yet Another Linked List"
HOMEPAGE = "https://github.com/isaacs/yallist#readme"

LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=82703a69f6d7411dde679954c2fd9dca"

SRC_URI = "https://registry.npmjs.org/yallist/-/yallist-2.1.2.tgz"
SRC_URI[md5sum] = "c75ab65aa7ee9067694839e685e3b39a"
SRC_URI[sha256sum] = "c7b31084d3525e17314b46c28e58ceb6cd8f10a9ff926daf48303976f8acb0b2"

NPM_PKGNAME = "yallist"

inherit npmhelper
inherit native
