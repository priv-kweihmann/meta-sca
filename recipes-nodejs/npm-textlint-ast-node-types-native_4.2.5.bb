SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.2.5.tgz"
SRC_URI[md5sum] = "c1407efcbaa6e639f0074877af7b2f8d"
SRC_URI[sha256sum] = "5bab1b521bba27c575ac7393251a8204599f9c7930c38b592030f5026192532b"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
