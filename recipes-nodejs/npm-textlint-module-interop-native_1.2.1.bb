SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.2.1.tgz"
SRC_URI[md5sum] = "117964b568cfbe82debe8de7b945cd78"
SRC_URI[sha256sum] = "22dbd91474e935ecfe2956f03a958cc9f295b9cba6f3afb300f534f92e0b820c"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
