SUMMARY = "NPM: eslint-config-standard-jsx"
DESCRIPTION = "JavaScript Standard Style JSX support - ESLint Shareable Config"
HOMEPAGE = "https://github.com/standard/eslint-config-standard-jsx"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984"

SRC_URI = "https://registry.npmjs.org/eslint-config-standard-jsx/-/eslint-config-standard-jsx-8.1.0.tgz"
SRC_URI[md5sum] = "ddecda383b64896ad5f38ff50a57e47f"
SRC_URI[sha256sum] = "9c8016da434c3c03a2611df33530ed53ab91968109089257c1961114aea0c400"

NPM_PKGNAME = "eslint-config-standard-jsx"

inherit npmhelper
inherit native
