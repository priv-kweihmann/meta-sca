SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.3.5.tgz"
SRC_URI[md5sum] = "a6e1058f97aad8d301620428b5050356"
SRC_URI[sha256sum] = "60624c4a6c0e1fffce9005de69748f67ea99086bb3f5f9aa984ff51738c85dc9"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
