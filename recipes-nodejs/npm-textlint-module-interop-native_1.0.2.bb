SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.0.2.tgz"
SRC_URI[md5sum] = "4286667b3c22a60bb3c0f72dd95eaaf8"
SRC_URI[sha256sum] = "1b3427689de13cbd8dd31b21b683ef47027dcdb9e73ca79c46a95bb7435d9255"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
