SUMMARY = "NPM: from"
DESCRIPTION = "Easy way to make a Readable Stream"
HOMEPAGE = "https://github.com/dominictarr/from#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1"

SRC_URI = "https://registry.npmjs.org/from/-/from-0.1.7.tgz"
SRC_URI[md5sum] = "a3264b42ed95b04200aed60decaca40a"
SRC_URI[sha256sum] = "ae329ea8fbe235040ad598b3de62aad5e53cc84dc7e2391d9c0edf3726bbc504"

NPM_PKGNAME = "from"

inherit npmhelper
inherit native
