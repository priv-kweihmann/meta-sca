SUMMARY = "NPM: is-retry-allowed"
DESCRIPTION = "Is retry allowed for Error?"
HOMEPAGE = "https://github.com/floatdrop/is-retry-allowed#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=be72c3ad86c1c4e9578a1945b082b17d"

SRC_URI = "https://registry.npmjs.org/is-retry-allowed/-/is-retry-allowed-1.2.0.tgz"
SRC_URI[md5sum] = "2461da87cc57e8ee4f93fa3c40c915c6"
SRC_URI[sha256sum] = "a49e24bd4c888bc54cc6c3f6468b033f96310a04af39316a03c8489718f85968"

NPM_PKGNAME = "is-retry-allowed"

inherit npmhelper
inherit native
