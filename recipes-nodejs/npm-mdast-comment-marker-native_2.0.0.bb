SUMMARY = "NPM: mdast-comment-marker"
DESCRIPTION = "mdast utility to parse a comment marker"
HOMEPAGE = "https://github.com/syntax-tree/mdast-comment-marker#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/mdast-comment-marker/-/mdast-comment-marker-2.0.0.tgz"
SRC_URI[md5sum] = "c504b0971301edd1ab1aff474ee05fae"
SRC_URI[sha256sum] = "5bfa1fbd8e91b2e6cad431429de7045b403b317dc8a2d4edbb5413c264b01b75"

NPM_PKGNAME = "mdast-comment-marker"

inherit npmhelper
inherit native
