SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-2.2.0.tgz"
SRC_URI[md5sum] = "001d86359e736db2deab88ad0f796f03"
SRC_URI[sha256sum] = "0cd1488b926e926980ffb2ecafddfe0c15fd9cdfcd2ff3ee287613c4a1661151"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
