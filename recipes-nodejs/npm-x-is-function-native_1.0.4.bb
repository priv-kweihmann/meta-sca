SUMMARY = "NPM: x-is-function"
DESCRIPTION = "Simple function test"
HOMEPAGE = "https://github.com/serapath/x-is-function#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3bfc61ed621763ad6ba20993bac6ac0a"

SRC_URI = "https://registry.npmjs.org/x-is-function/-/x-is-function-1.0.4.tgz"
SRC_URI[md5sum] = "5f059486b32837d0a19ad8e62eef0127"
SRC_URI[sha256sum] = "f4341e9fa083c6f8101793db02a11909e6939d101b144ad277905c22fb219819"

NPM_PKGNAME = "x-is-function"

inherit npmhelper
inherit native
