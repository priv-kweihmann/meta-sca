SUMMARY = "NPM: unist-util-position"
DESCRIPTION = "unist utility to get the position of a node"
HOMEPAGE = "https://github.com/syntax-tree/unist-util-position#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/unist-util-position/-/unist-util-position-3.1.0.tgz"
SRC_URI[md5sum] = "c2824982171647410ffb475636c34e6f"
SRC_URI[sha256sum] = "93614e243050f5ab676f4668e8520b3ac7c42fb0157b185a358975e9f8f4de35"

NPM_PKGNAME = "unist-util-position"

inherit npmhelper
inherit native
