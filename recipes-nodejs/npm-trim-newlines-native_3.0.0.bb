SUMMARY = "NPM: trim-newlines"
DESCRIPTION = "Trim newlines from the start and/or end of a string"
HOMEPAGE = "https://github.com/sindresorhus/trim-newlines#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

SRC_URI = "https://registry.npmjs.org/trim-newlines/-/trim-newlines-3.0.0.tgz"
SRC_URI[md5sum] = "bd417b08208f01c7a628dd66f604a902"
SRC_URI[sha256sum] = "9a52265b5b022a5a26e12b3762ce2782ae0aec9dda749c8e911a7dc093ba404b"

NPM_PKGNAME = "trim-newlines"

inherit npmhelper
inherit native
