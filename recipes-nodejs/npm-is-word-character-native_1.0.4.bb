SUMMARY = "NPM: is-word-character"
DESCRIPTION = "Check if a character is a word character"
HOMEPAGE = "https://github.com/wooorm/is-word-character#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/is-word-character/-/is-word-character-1.0.4.tgz"
SRC_URI[md5sum] = "2baf2f67e1b5ce7dc8d6d1f0061209e0"
SRC_URI[sha256sum] = "c0b66a1f8c40ea3388abd01c832cd6209ac776afb747439b2840a971f37cb6de"

NPM_PKGNAME = "is-word-character"

inherit npmhelper
inherit native
