SUMMARY = "NPM: unist-util-is"
DESCRIPTION = "unist utility to check if a node passes a test"
HOMEPAGE = "https://github.com/syntax-tree/unist-util-is#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=129a18b8487c2727a4ae7d7e2ad7b231"

SRC_URI = "https://registry.npmjs.org/unist-util-is/-/unist-util-is-4.0.2.tgz"
SRC_URI[md5sum] = "c5c33592aeacbcc8cc97512535a48990"
SRC_URI[sha256sum] = "e92085a4ba4bf91cb3197b27d5263973c7bbe763235cb5eb19151485bf0510fb"

NPM_PKGNAME = "unist-util-is"

inherit npmhelper
inherit native
