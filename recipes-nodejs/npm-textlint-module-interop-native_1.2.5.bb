SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.2.5.tgz"
SRC_URI[md5sum] = "7cec65fa83ecef85e84660037ac06260"
SRC_URI[sha256sum] = "385140dc5022915b1168df2105a9f3d9173b47fcd9b9d6bb4ddc1eefc8982aa0"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
