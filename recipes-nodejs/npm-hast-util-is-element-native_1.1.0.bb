SUMMARY = "NPM: hast-util-is-element"
DESCRIPTION = "hast utility to check if a node is a (certain) element"
HOMEPAGE = "https://github.com/syntax-tree/hast-util-is-element#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-is-element/-/hast-util-is-element-1.1.0.tgz"
SRC_URI[md5sum] = "410748a9dff5b5e31969f42063b9542a"
SRC_URI[sha256sum] = "3ed9d860fe66f77176d8819e0e292334a7860b9da472042f84aac90ad645e369"

NPM_PKGNAME = "hast-util-is-element"

inherit npmhelper
inherit native
