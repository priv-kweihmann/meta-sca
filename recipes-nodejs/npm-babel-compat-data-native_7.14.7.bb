SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.14.7.tgz"
SRC_URI[md5sum] = "747c04bafd47fd389e5b322abc3e6956"
SRC_URI[sha256sum] = "294dd1e29802307a0208ebba450f845450fd91d095d50107697dd29e751c4963"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
