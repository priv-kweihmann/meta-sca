SUMMARY = "NPM: @getify/eslint-plugin-proper-arrows"
DESCRIPTION = "ESLint rules to ensure proper arrow function definitions"
HOMEPAGE = "https://github.com/getify/eslint-plugin-proper-arrows"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1d94c8e9d6efb6e3b31b75ff3c6fe905"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@getify/eslint-plugin-proper-arrows/-/eslint-plugin-proper-arrows-10.0.0.tgz"
SRC_URI[md5sum] = "f2badf1e226adb773155ec6874d2a9e6"
SRC_URI[sha256sum] = "1af55c52e328d039dd0c9b517e6f4dbd58fdfd84452bac2573ff657dab486a49"

NPM_PKGNAME = "@getify/eslint-plugin-proper-arrows"

inherit npmhelper
inherit native
