SUMMARY = "NPM: quotation"
DESCRIPTION = "Quote a value"
HOMEPAGE = "https://github.com/wooorm/quotation#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/quotation/-/quotation-1.1.3.tgz"
SRC_URI[md5sum] = "82824b6fb9fea7f867453fce3f175392"
SRC_URI[sha256sum] = "876e759b56eebb8cd14f27d2ef8620c91f69f0d77d36cebc8d69148ce4aa132d"

NPM_PKGNAME = "quotation"

inherit npmhelper
inherit native
