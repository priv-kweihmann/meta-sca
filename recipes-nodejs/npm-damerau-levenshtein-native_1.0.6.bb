SUMMARY = "NPM: damerau-levenshtein"
DESCRIPTION = "Damerau - Levenshtein distance by The Spanish Inquisition + relative distance"
HOMEPAGE = "https://github.com/tad-lispy/node-damerau-levenshtein#readme"

LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=515a31477042f4c100e408de987a0b5b"

SRC_URI = "https://registry.npmjs.org/damerau-levenshtein/-/damerau-levenshtein-1.0.6.tgz"
SRC_URI[md5sum] = "a935d6cf5533f0dcf246090d5e9331a7"
SRC_URI[sha256sum] = "c9bffb8143122543462c1db705fecc7d3bb1117399cdf574b66a9ffd1fb22f21"

NPM_PKGNAME = "damerau-levenshtein"

inherit npmhelper
inherit native
