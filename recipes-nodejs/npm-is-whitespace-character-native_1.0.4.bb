SUMMARY = "NPM: is-whitespace-character"
DESCRIPTION = "Check if a character is a whitespace character"
HOMEPAGE = "https://github.com/wooorm/is-whitespace-character#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/is-whitespace-character/-/is-whitespace-character-1.0.4.tgz"
SRC_URI[md5sum] = "60edc805a75cc75599fab335bef1809c"
SRC_URI[sha256sum] = "75f08f4ef0f09da2c3b625f3f82e1698dbd5e88f74b5a9dfc4b130b21f644273"

NPM_PKGNAME = "is-whitespace-character"

inherit npmhelper
inherit native
