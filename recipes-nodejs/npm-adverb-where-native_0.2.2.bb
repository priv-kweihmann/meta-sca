SUMMARY = "NPM: adverb-where"
DESCRIPTION = "Find adverbs in your writings"
HOMEPAGE = "https://github.com/duereg/adverb-where"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ad1ea741b5c8f9d521103277c196d2dd"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/adverb-where/-/adverb-where-0.2.2.tgz"
SRC_URI[md5sum] = "9630d0c4af9d6ac6e244b1e88de74ace"
SRC_URI[sha256sum] = "1e0e4dfda227dd119af84887b7b6dc7e6125d9a805143ada79841c5266f9b2e1"

NPM_PKGNAME = "adverb-where"

inherit npmhelper
inherit native
