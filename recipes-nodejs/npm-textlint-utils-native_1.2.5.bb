SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.2.5.tgz"
SRC_URI[md5sum] = "0fd6a2820a50089bded796d9fc067b28"
SRC_URI[sha256sum] = "d5b4417c23ddc5f7bad1eba59896be99b959e27646ab34cf5b530ada6a3e676d"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
