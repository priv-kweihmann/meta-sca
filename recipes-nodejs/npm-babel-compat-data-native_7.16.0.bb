SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.16.0.tgz"
SRC_URI[md5sum] = "ccb1c20cb2b620a5abf64c63dd9c8bd0"
SRC_URI[sha256sum] = "486f98ad1bc66409975f4eb35190d22fe464d56ff8487fcc9b9c7815f819786a"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
