SUMMARY = "NPM: state-toggle"
DESCRIPTION = "Enter/exit a state"
HOMEPAGE = "https://github.com/wooorm/state-toggle#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/state-toggle/-/state-toggle-1.0.3.tgz"
SRC_URI[md5sum] = "ae7ac3cad862a75a98727b6f8f1f5de8"
SRC_URI[sha256sum] = "5f5cde91060dec4206bdedf8a080e49d7eefe6278ccd9809726edefab77b3855"

NPM_PKGNAME = "state-toggle"

inherit npmhelper
inherit native
