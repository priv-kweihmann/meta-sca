SUMMARY = "NPM: @babel/helper-validator-identifier"
DESCRIPTION = "Validate identifier/keywords name"


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

SRC_URI = "https://registry.npmjs.org/@babel/helper-validator-identifier/-/helper-validator-identifier-7.9.5.tgz"
SRC_URI[md5sum] = "de80634110e01148c00a9454e1e29b69"
SRC_URI[sha256sum] = "ecf42a8f24aafc54def5936befb29c25b3db686d1b12d2b559a9c9bc57f91ba5"

NPM_PKGNAME = "@babel/helper-validator-identifier"

inherit npmhelper
inherit native
