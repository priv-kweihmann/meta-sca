SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.14.4.tgz"
SRC_URI[md5sum] = "2e96fd313ea517f04228cf7ed121e3a1"
SRC_URI[sha256sum] = "7960f5f975facc51314b7bb9b9127ff30efe633212940693b0e6a14e1bf67a0e"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
