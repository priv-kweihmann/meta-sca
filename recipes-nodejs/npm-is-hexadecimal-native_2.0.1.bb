SUMMARY = "NPM: is-hexadecimal"
DESCRIPTION = "Check if a character is hexadecimal"
HOMEPAGE = "https://github.com/wooorm/is-hexadecimal#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/is-hexadecimal/-/is-hexadecimal-2.0.1.tgz"
SRC_URI[md5sum] = "63b4ace5c50a3978c7f6dae4e69227c9"
SRC_URI[sha256sum] = "6234c672b1134b6ebc8b162eb119a4b1beebc6cd9217bdc66b2b9822570f8d81"

NPM_PKGNAME = "is-hexadecimal"

inherit npmhelper
inherit native
