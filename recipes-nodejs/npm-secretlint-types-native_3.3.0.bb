SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-3.3.0.tgz"
SRC_URI[md5sum] = "6041da236effe933f3771bef2477f93f"
SRC_URI[sha256sum] = "124888e6d5dc991e47d7a6a38ab29e04f69b1c1e1d6dad4c249face46b350a01"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
