SUMMARY = "NPM: @sindresorhus/is"
DESCRIPTION = "Type check values"
HOMEPAGE = "https://github.com/sindresorhus/is#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=d5f2a6dd0192dcc7c833e50bb9017337"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@sindresorhus/is/-/is-3.1.1.tgz"
SRC_URI[md5sum] = "e046511684465aa5dcd40706bf2c52c8"
SRC_URI[sha256sum] = "b607e66bcbb3275512748af911890e348a070bce50787b789b28b0c7262f70e0"

NPM_PKGNAME = "@sindresorhus/is"

inherit npmhelper
inherit native
