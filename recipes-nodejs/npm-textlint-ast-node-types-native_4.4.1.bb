SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.4.1.tgz"
SRC_URI[md5sum] = "6078165545bba43dba5bc0ab24101e6b"
SRC_URI[sha256sum] = "47f08a6f6fe2787085dcb12a5708e1822f38439d0f271750b128a9b86f0d17d3"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
