SUMMARY = "NPM: p-cancelable"
DESCRIPTION = "Create a promise that can be canceled"
HOMEPAGE = "https://github.com/sindresorhus/p-cancelable#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/p-cancelable/-/p-cancelable-1.1.0.tgz"
SRC_URI[md5sum] = "0b5696727cd875f488c8f86d0e5b3ce5"
SRC_URI[sha256sum] = "5b3d0bbe88fa4763428bdbdbecc19d7aa3c168d19b38d26751c9abc785602499"

NPM_PKGNAME = "p-cancelable"

inherit npmhelper
inherit native
