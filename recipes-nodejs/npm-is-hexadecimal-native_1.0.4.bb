SUMMARY = "NPM: is-hexadecimal"
DESCRIPTION = "Check if a character is hexadecimal"
HOMEPAGE = "https://github.com/wooorm/is-hexadecimal#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/is-hexadecimal/-/is-hexadecimal-1.0.4.tgz"
SRC_URI[md5sum] = "ec0686d631e861e1e5c8a2d0196b8a82"
SRC_URI[sha256sum] = "6c26bfbc03076f6807985368000462ec93e263792524a557c124b5e7c9cd27ca"

NPM_PKGNAME = "is-hexadecimal"

inherit npmhelper
inherit native
