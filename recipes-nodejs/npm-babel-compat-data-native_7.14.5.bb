SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.14.5.tgz"
SRC_URI[md5sum] = "72d567893a050b42605c166432efbecb"
SRC_URI[sha256sum] = "316b0ffe4544e0c17e4c5244f1620757a6cdec6d9f0bd02aa5c699c914687727"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
