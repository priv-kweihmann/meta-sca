SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.2.3.tgz"
SRC_URI[md5sum] = "2ffb5f85fb886991c680b7deee3cdc50"
SRC_URI[sha256sum] = "230cd0840945469969bf880ea07be21ad7df1f951fdd3bae9b660d27dcff934c"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
