SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-12.0.0.tgz"
SRC_URI[md5sum] = "fd50ffe3e9ba00952894b4c1e340e4b7"
SRC_URI[sha256sum] = "2f89a625ae067c434e5ed618ea06f51efe0a54f05a9b11017064d6f218179d3c"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
