SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.13.11.tgz"
SRC_URI[md5sum] = "82f1469f3b43da5960287f57f9314166"
SRC_URI[sha256sum] = "97deda40c8ba007bfad2dd016ad2021bad089d3b72ac9b1840037b050b627bd0"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
