SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.13.15.tgz"
SRC_URI[md5sum] = "d2a47b0b811ee4ec3e2566673e72c705"
SRC_URI[sha256sum] = "aca6ff3737aff6abd730b4f24652c9aecb26360ea6c4b2dbacbc9bfe5e26c36f"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
