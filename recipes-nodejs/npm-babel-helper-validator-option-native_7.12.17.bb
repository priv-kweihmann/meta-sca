SUMMARY = "NPM: @babel/helper-validator-option"
DESCRIPTION = "Validate plugin/preset options"
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/helper-validator-option/-/helper-validator-option-7.12.17.tgz"
SRC_URI[md5sum] = "07d06247d4a4f5cfdc3613ec62491efc"
SRC_URI[sha256sum] = "bc40a40d54911f37c666a7beaa3dbbf631f0525f1b17c8148187c1024544b64d"

NPM_PKGNAME = "@babel/helper-validator-option"

inherit npmhelper
inherit native
