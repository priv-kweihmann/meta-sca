SUMMARY = "NPM: array-find-index"
DESCRIPTION = "ES2015 `Array#findIndex()` ponyfill"
HOMEPAGE = "https://github.com/sindresorhus/array-find-index#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/array-find-index/-/array-find-index-1.0.2.tgz"
SRC_URI[md5sum] = "32a8721a9617cd4e6198101821b0c823"
SRC_URI[sha256sum] = "05ea6cb80af8863ab910004a81179301357956f96a1f78151f348a4b19213bc6"

NPM_PKGNAME = "array-find-index"

inherit npmhelper
inherit native
