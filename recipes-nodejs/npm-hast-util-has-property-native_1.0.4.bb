SUMMARY = "NPM: hast-util-has-property"
DESCRIPTION = "hast utility to check if a node has a property"
HOMEPAGE = "https://github.com/syntax-tree/hast-util-has-property#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-has-property/-/hast-util-has-property-1.0.4.tgz"
SRC_URI[md5sum] = "5069be0573d5d0de6d21713a24a0c6df"
SRC_URI[sha256sum] = "c91612a9ce5aa317ade70b34a22132bd1502ed2c086dbf3cb1f351e573d766a9"

NPM_PKGNAME = "hast-util-has-property"

inherit npmhelper
inherit native
