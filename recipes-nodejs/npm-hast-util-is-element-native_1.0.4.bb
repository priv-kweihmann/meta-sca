SUMMARY = "NPM: hast-util-is-element"
DESCRIPTION = "hast utility to check if a node is a (certain) element"
HOMEPAGE = "https://github.com/syntax-tree/hast-util-is-element#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-is-element/-/hast-util-is-element-1.0.4.tgz"
SRC_URI[md5sum] = "ee72277c674952288611ce5791e721ac"
SRC_URI[sha256sum] = "da66f0caf654981d96825e9f1cf7fa4fc6d7802306249ab55980b72c3bb7c0d3"

NPM_PKGNAME = "hast-util-is-element"

inherit npmhelper
inherit native
