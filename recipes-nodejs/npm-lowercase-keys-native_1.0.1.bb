SUMMARY = "NPM: lowercase-keys"
DESCRIPTION = "Lowercase the keys of an object"
HOMEPAGE = "https://github.com/sindresorhus/lowercase-keys#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/lowercase-keys/-/lowercase-keys-1.0.1.tgz"
SRC_URI[md5sum] = "de9b080b5e473d21200e69b8bfc7c204"
SRC_URI[sha256sum] = "e8e8790d430a8250da4d1b4821051c7da7bdb2081e9d62d7270e0a5de99a42cb"

NPM_PKGNAME = "lowercase-keys"

inherit npmhelper
inherit native
