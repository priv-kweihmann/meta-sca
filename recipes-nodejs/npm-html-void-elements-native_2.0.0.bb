SUMMARY = "NPM: html-void-elements"
DESCRIPTION = "List of known void HTML elements"
HOMEPAGE = "https://github.com/wooorm/html-void-elements#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/html-void-elements/-/html-void-elements-2.0.0.tgz"
SRC_URI[md5sum] = "95d874d448cd5a6763d14810e23e51c1"
SRC_URI[sha256sum] = "3d90bf8f389a2447483dc16d9c9390206ab3b921c26b0aebf38e8430d60e14ea"

NPM_PKGNAME = "html-void-elements"

inherit npmhelper
inherit native
