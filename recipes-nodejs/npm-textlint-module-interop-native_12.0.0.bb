SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-12.0.0.tgz"
SRC_URI[md5sum] = "405adf75ca8d945b362306945945cf83"
SRC_URI[sha256sum] = "e62b9b474d687ee98d29058e88063a48e85d4572e7880218d69f28f1b6dd1aa8"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
