SUMMARY = "NPM: p-cancelable"
DESCRIPTION = "Create a promise that can be canceled"
HOMEPAGE = "https://github.com/sindresorhus/p-cancelable#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/p-cancelable/-/p-cancelable-2.1.0.tgz"
SRC_URI[md5sum] = "ac37d979e4921f4f00a053cd108058f6"
SRC_URI[sha256sum] = "a606ad5ea7fc116166903aecae303f6b238ce02bccc0471fec109bcf5e6ecec2"

NPM_PKGNAME = "p-cancelable"

inherit npmhelper
inherit native
