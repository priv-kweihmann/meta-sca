SUMMARY = "NPM: space-separated-tokens"
DESCRIPTION = "Parse and stringify space separated tokens"
HOMEPAGE = "https://github.com/wooorm/space-separated-tokens#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/space-separated-tokens/-/space-separated-tokens-2.0.0.tgz"
SRC_URI[md5sum] = "fe87ac95dab1025dbfe24725393df110"
SRC_URI[sha256sum] = "69d38f46f395f4e75cbd9b4172a1758daebb49f6eb48693b77c9b6367b9f87cc"

NPM_PKGNAME = "space-separated-tokens"

inherit npmhelper
inherit native
