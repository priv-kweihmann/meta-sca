SUMMARY = "NPM: eslint-plugin-array-func"
DESCRIPTION = "Rules dealing with Array functions and methods."
HOMEPAGE = "https://github.com/freaktechnik/eslint-plugin-array-func#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a21b38275e7647340357b8e707f61495"

SRC_URI = "https://registry.npmjs.org/eslint-plugin-array-func/-/eslint-plugin-array-func-3.1.5.tgz"
SRC_URI[md5sum] = "c8a075e8d3fe576b115c4cce3088cef6"
SRC_URI[sha256sum] = "adaa02058a1e844465b5ed35ffb107a9df56f340dcd3e36dfa5b14d48d4931df"

NPM_PKGNAME = "eslint-plugin-array-func"

inherit npmhelper
inherit native
