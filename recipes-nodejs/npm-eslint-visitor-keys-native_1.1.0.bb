SUMMARY = "NPM: eslint-visitor-keys"
DESCRIPTION = "Constants and utilities about visitor keys to traverse AST."
HOMEPAGE = "https://github.com/eslint/eslint-visitor-keys#readme"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e93e1daed697456bb93ade9a07cd1816"

SRC_URI = "https://registry.npmjs.org/eslint-visitor-keys/-/eslint-visitor-keys-1.1.0.tgz"
SRC_URI[md5sum] = "fbcaf00e3998617d87ee25b0bac8912e"
SRC_URI[sha256sum] = "071cdd8c0a140ff0ab13ba4b41f37ccd76017202d5e1948a9408c95aead21439"

NPM_PKGNAME = "eslint-visitor-keys"

inherit npmhelper
inherit native
