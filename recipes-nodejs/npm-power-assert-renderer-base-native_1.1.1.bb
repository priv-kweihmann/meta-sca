SUMMARY = "NPM: power-assert-renderer-base"
DESCRIPTION = "base renderer for power-assert context"
HOMEPAGE = "https://github.com/twada/power-assert-runtime"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.md;beginline=43;endline=44;md5=fb09d58b915b126f1c353f70c292ce4e"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/power-assert-renderer-base/-/power-assert-renderer-base-1.1.1.tgz"
SRC_URI[md5sum] = "f9eb920bc0d8d76acddf99f903993efa"
SRC_URI[sha256sum] = "d37e00979f1e4e0437fc9df8a817ad50cb6d4c208b32ae9af2c58da3b937009c"

NPM_PKGNAME = "power-assert-renderer-base"

inherit npmhelper
inherit native
