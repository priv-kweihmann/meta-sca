SUMMARY = "NPM: @babel/helper-split-export-declaration"
DESCRIPTION = ">"
DEPENDS = "npm-babel-types-native"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

SRC_URI = "https://registry.npmjs.org/@babel/helper-split-export-declaration/-/helper-split-export-declaration-7.8.3.tgz"
SRC_URI[md5sum] = "79765ac50962dd8032aa1850e5c28722"
SRC_URI[sha256sum] = "5c86fe2ee874109a76d41c18dfade28606464b6406c59e1f1a0a81d9e5da7c4f"

NPM_PKGNAME = "@babel/helper-split-export-declaration"

inherit npmhelper
inherit native
