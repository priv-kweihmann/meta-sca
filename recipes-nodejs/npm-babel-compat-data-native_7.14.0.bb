SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.14.0.tgz"
SRC_URI[md5sum] = "0ed6739e361ae60428b3a1c7a41021db"
SRC_URI[sha256sum] = "c7de333fe3c86ee51bb54b9dbc7ae922d7583c377eb380045efe257506f09eed"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
