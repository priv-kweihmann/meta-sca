SUMMARY = "NPM: is-alphabetical"
DESCRIPTION = "Check if a character is alphabetical"
HOMEPAGE = "https://github.com/wooorm/is-alphabetical#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/is-alphabetical/-/is-alphabetical-2.0.0.tgz"
SRC_URI[md5sum] = "55b9d798b0077b82ac63948778c57608"
SRC_URI[sha256sum] = "efa7499b61e62ece53ab3579c4a579688cbbbb0318bddddad1d7c29b2ff7fea3"

NPM_PKGNAME = "is-alphabetical"

inherit npmhelper
inherit native
