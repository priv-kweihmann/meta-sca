SUMMARY = "NPM: stylelint-config-recommended"
DESCRIPTION = "Recommended shareable config for stylelint"
HOMEPAGE = "https://github.com/stylelint/stylelint-config-recommended#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c225e22848adafaba08d945c6bc9e596"

SRC_URI = "https://registry.npmjs.org/stylelint-config-recommended/-/stylelint-config-recommended-3.0.0.tgz"
SRC_URI[md5sum] = "7006f144aabd81282d0c3c11433a3d0b"
SRC_URI[sha256sum] = "a3a02763b6688d8572c15df4b91cd6aaa859bbff54318ec4a6840d037aa805dc"

NPM_PKGNAME = "stylelint-config-recommended"

inherit npmhelper
inherit native
