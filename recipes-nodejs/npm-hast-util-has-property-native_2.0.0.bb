SUMMARY = "NPM: hast-util-has-property"
DESCRIPTION = "hast utility to check if a node has a property"
HOMEPAGE = "https://github.com/syntax-tree/hast-util-has-property#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-has-property/-/hast-util-has-property-2.0.0.tgz"
SRC_URI[md5sum] = "27e2ce06a9e5027437d4aedffc71125a"
SRC_URI[sha256sum] = "34731a30562fef115f4c974373adec87b87eb2e9743e6b75ccb567320144de0e"

NPM_PKGNAME = "hast-util-has-property"

inherit npmhelper
inherit native
