SUMMARY = "NPM: req-all"
DESCRIPTION = "Require all files in a directory"
HOMEPAGE = "https://github.com/sindresorhus/req-all#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/req-all/-/req-all-0.1.0.tgz"
SRC_URI[md5sum] = "44930c5377392f4fa1b11a2178683485"
SRC_URI[sha256sum] = "3aadc975d5203bb57a5dbefe95fee22c5c8139c41f0c0317821af7e7425edd89"

NPM_PKGNAME = "req-all"

inherit npmhelper
inherit native
