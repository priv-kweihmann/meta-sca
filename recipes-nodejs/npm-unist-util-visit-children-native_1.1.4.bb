SUMMARY = "NPM: unist-util-visit-children"
DESCRIPTION = "utility to visit direct children of a parent"
HOMEPAGE = "https://github.com/syntax-tree/unist-util-visit-children#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/unist-util-visit-children/-/unist-util-visit-children-1.1.4.tgz"
SRC_URI[md5sum] = "00a6c976cd56ea557759eec0aa0a1895"
SRC_URI[sha256sum] = "9bd0d6a0465b641ba883406cd85bb30298da5d6d039edcce994bfffc42692535"

NPM_PKGNAME = "unist-util-visit-children"

inherit npmhelper
inherit native
