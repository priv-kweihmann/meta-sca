SUMMARY = "NPM: is-arrayish"
DESCRIPTION = "Determines if an object can be used as an array"
HOMEPAGE = "https://github.com/qix-/node-is-arrayish#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/is-arrayish/-/is-arrayish-0.3.2.tgz"
SRC_URI[md5sum] = "a9411b733475f463a53cdf8656ad0811"
SRC_URI[sha256sum] = "01d66e497e5919652a1da343220e894e4915b80ad3efba60324eb422ff97ea32"

NPM_PKGNAME = "is-arrayish"

inherit npmhelper
inherit native
