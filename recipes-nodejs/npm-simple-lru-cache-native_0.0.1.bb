SUMMARY = "NPM: simple-lru-cache"
DESCRIPTION = "node-simple-lru-cache ====================="


LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1c38eccb8acd88c71e334405d972f483"

SRC_URI = "https://registry.npmjs.org/simple-lru-cache/-/simple-lru-cache-0.0.1.tgz"
SRC_URI[md5sum] = "bfa68c46f3c8295329075b23a3c1b83d"
SRC_URI[sha256sum] = "6e53d205388f76a930170c0dfafa1e9b9d45182ba364aaafb8c347153f3afd6f"

NPM_PKGNAME = "simple-lru-cache"

inherit npmhelper
inherit native
