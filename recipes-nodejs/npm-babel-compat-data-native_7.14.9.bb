SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.14.9.tgz"
SRC_URI[md5sum] = "4f5bad3dc4321e4fcf600472c7fff7d9"
SRC_URI[sha256sum] = "40d5ae960632327a82dc1ff3d55a3bd9c5a7c8cb9023dd0c36fac480ab887204"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
