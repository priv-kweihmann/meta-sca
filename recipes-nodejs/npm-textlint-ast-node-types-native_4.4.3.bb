SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.4.3.tgz"
SRC_URI[md5sum] = "de9dfe8eb9af74d273a1ce15a703f7c7"
SRC_URI[sha256sum] = "7b6109d2714cacba09cd1099d3913f01a9d504248f65f2e1d43b89915f77e606"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
