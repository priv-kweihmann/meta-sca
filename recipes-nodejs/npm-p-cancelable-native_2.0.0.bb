SUMMARY = "NPM: p-cancelable"
DESCRIPTION = "Create a promise that can be canceled"
HOMEPAGE = "https://github.com/sindresorhus/p-cancelable#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/p-cancelable/-/p-cancelable-2.0.0.tgz"
SRC_URI[md5sum] = "5013b42bfff25a063a149a188123a479"
SRC_URI[sha256sum] = "f304688bdafc9d3f4c603bbc552ca5256e2519ae20ef54ca59f4d4fbdbf284ce"

NPM_PKGNAME = "p-cancelable"

inherit npmhelper
inherit native
