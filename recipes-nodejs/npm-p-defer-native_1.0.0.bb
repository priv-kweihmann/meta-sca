SUMMARY = "NPM: p-defer"
DESCRIPTION = "Create a deferred promise"
HOMEPAGE = "https://github.com/sindresorhus/p-defer#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/p-defer/-/p-defer-1.0.0.tgz"
SRC_URI[md5sum] = "5efa4cf3c55e75e8fb128e353d77a119"
SRC_URI[sha256sum] = "b201178e6638ab99188a641e9503ce1e81bca878a513078023b3bbbd232dfcc7"

NPM_PKGNAME = "p-defer"

inherit npmhelper
inherit native
