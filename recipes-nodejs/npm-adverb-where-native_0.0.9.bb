SUMMARY = "NPM: adverb-where"
DESCRIPTION = "Find adverbs in your writings"
HOMEPAGE = "https://github.com/duereg/adverb-where"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ad1ea741b5c8f9d521103277c196d2dd"

SRC_URI = "https://registry.npmjs.org/adverb-where/-/adverb-where-0.0.9.tgz"
SRC_URI[md5sum] = "227f6867e5fe9d513ddcbfc1f435ec92"
SRC_URI[sha256sum] = "674593bcaeaba2abce4724df011e64e2e2e9e355035a9c3fc1675abd95f7986b"

NPM_PKGNAME = "adverb-where"

inherit npmhelper
inherit native
