SUMMARY = "NPM: character-entities-legacy"
DESCRIPTION = "HTML legacy character entity information"
HOMEPAGE = "https://github.com/wooorm/character-entities-legacy#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/character-entities-legacy/-/character-entities-legacy-2.0.0.tgz"
SRC_URI[md5sum] = "06baa9812c4162a798808518d3c273e6"
SRC_URI[sha256sum] = "31bcbce99f2b0a113c04f9df17b5f5f305aab7f486fde74fee6d5939ba354858"

NPM_PKGNAME = "character-entities-legacy"

inherit npmhelper
inherit native
