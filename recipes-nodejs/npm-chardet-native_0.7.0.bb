SUMMARY = "NPM: chardet"
DESCRIPTION = "Character detector"
HOMEPAGE = "https://github.com/runk/node-chardet"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=14e7b59fb0b28b80dd4e858e9e0a5629"

SRC_URI = "https://registry.npmjs.org/chardet/-/chardet-0.7.0.tgz"
SRC_URI[md5sum] = "2d3af06beead0821b7acbbf3ff302f64"
SRC_URI[sha256sum] = "5a3abab769cf4a059a6c5d35d34085fbfe7af2c7f51f0a4ccdfe7b76b0c6efe7"

NPM_PKGNAME = "chardet"

inherit npmhelper
inherit native
