SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.1.4.tgz"
SRC_URI[md5sum] = "3a8c32845400888a291068a5f9468721"
SRC_URI[sha256sum] = "b23f6e8a037fc308f4be0b3a1535e949ea82931f377e2b6e3b0b93ae9725adb1"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
