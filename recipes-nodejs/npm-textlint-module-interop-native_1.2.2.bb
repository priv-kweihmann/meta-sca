SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.2.2.tgz"
SRC_URI[md5sum] = "cafce62c99d8fa4d3d8655d8b0b637aa"
SRC_URI[sha256sum] = "263cecf5cd1b088c7b8019a80914b753882501c73f38242fcbeeb819f61c6e67"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
