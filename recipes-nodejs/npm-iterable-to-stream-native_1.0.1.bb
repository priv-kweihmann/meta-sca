SUMMARY = "NPM: iterable-to-stream"
DESCRIPTION = "Converts iterable objects into readable streams."
HOMEPAGE = "https://github.com/Jason3S/iterable-to-stream#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d6c2f216355cbd3a4d1d54e29f56a409"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/iterable-to-stream/-/iterable-to-stream-1.0.1.tgz"
SRC_URI[md5sum] = "11c2174f4f19a8817e9545d4e03bef4f"
SRC_URI[sha256sum] = "04220341986d4f92c2957d831982452a089ee515e95a7165cc4f92397268abd1"

NPM_PKGNAME = "iterable-to-stream"

inherit npmhelper
inherit native
