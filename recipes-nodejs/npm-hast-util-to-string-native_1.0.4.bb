SUMMARY = "NPM: hast-util-to-string"
DESCRIPTION = "hast utility to get the plain-text value of a node"
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://readme.md;beginline=53;endline=54;md5=f7cd6e61bbbca39fe0e60b4899302d5a"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-to-string/-/hast-util-to-string-1.0.4.tgz"
SRC_URI[md5sum] = "fbabbb9b130673870329b9ef91301396"
SRC_URI[sha256sum] = "a9f28c0b0c815640549f4c9ddb2444d21c4dbfed42fb9499bfd070c1802dea85"

NPM_PKGNAME = "hast-util-to-string"

inherit npmhelper
inherit native
