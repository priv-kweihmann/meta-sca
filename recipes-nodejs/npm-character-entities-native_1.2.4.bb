SUMMARY = "NPM: character-entities"
DESCRIPTION = "HTML character entity information"
HOMEPAGE = "https://github.com/wooorm/character-entities#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/character-entities/-/character-entities-1.2.4.tgz"
SRC_URI[md5sum] = "efbb9c231c7f307f9d37228796f302f8"
SRC_URI[sha256sum] = "3d00ecbd0e5ee404524f87eba877c280a4a1f75cc91fc6b10e6a5ed624799d21"

NPM_PKGNAME = "character-entities"

inherit npmhelper
inherit native
