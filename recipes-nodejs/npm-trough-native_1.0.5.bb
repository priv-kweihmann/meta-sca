SUMMARY = "NPM: trough"
DESCRIPTION = "Middleware: a channel used to convey a liquid"
HOMEPAGE = "https://github.com/wooorm/trough#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=b280acbcf1c2e5ef4ceb6852568d9961"

SRC_URI = "https://registry.npmjs.org/trough/-/trough-1.0.5.tgz"
SRC_URI[md5sum] = "8208c991bb6f3aa350b761582992ff06"
SRC_URI[sha256sum] = "4ae452da57bc8d50a527c907acd4a867ca3e6c5ae240fb0bce290ce0dedc15db"

NPM_PKGNAME = "trough"

inherit npmhelper
inherit native
