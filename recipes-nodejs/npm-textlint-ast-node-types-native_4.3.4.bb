SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.3.4.tgz"
SRC_URI[md5sum] = "29a3bce45c3f40c0a055cd31e8eb780c"
SRC_URI[sha256sum] = "817cfbe6b93d8b455d544cb6d1d71ded40dd92a238eab81c5bc9e71728e7b923"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
