SUMMARY = "NPM: js-types"
DESCRIPTION = "List of JavaScript types"
HOMEPAGE = "https://github.com/sindresorhus/js-types"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/js-types/-/js-types-1.0.0.tgz"
SRC_URI[md5sum] = "60cccf96110592ca167c2c9b98155a45"
SRC_URI[sha256sum] = "f6cd2355c0f1cdacd4c1a97f0172a9d224b7376c2f7fa671af2e9706bfd1eb85"

NPM_PKGNAME = "js-types"

inherit npmhelper
inherit native
