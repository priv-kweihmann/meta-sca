SUMMARY = "NPM: adverb-where"
DESCRIPTION = "Find adverbs in your writings"
HOMEPAGE = "https://github.com/duereg/adverb-where"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ad1ea741b5c8f9d521103277c196d2dd"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/adverb-where/-/adverb-where-0.2.1.tgz"
SRC_URI[md5sum] = "8f9e1bd6120daf4a975c2ca646692c76"
SRC_URI[sha256sum] = "8e1a117c1d9da55a27a8334f09b204be8166ef10a567648afe9b0957d43a7c5a"

NPM_PKGNAME = "adverb-where"

inherit npmhelper
inherit native
