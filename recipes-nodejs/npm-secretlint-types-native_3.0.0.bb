SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-3.0.0.tgz"
SRC_URI[md5sum] = "99cddeaca4accf872844ffcbc32c6006"
SRC_URI[sha256sum] = "76f28ca9396b4f2d7415a82bfed824ce0f0ea9a3d0ccce69fbc6fd56c04dd9bc"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
