SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.2.1.tgz"
SRC_URI[md5sum] = "2b10d30beea348d0266e24ed7ef80412"
SRC_URI[sha256sum] = "7b0c84ef28779a7fdce73d042c5bf0938a9969909a39112d8d537e92deb397a3"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
