SUMMARY = "NPM: fn-name"
DESCRIPTION = "Get the name of a named function"
HOMEPAGE = "https://github.com/sindresorhus/fn-name"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/fn-name/-/fn-name-2.0.1.tgz"
SRC_URI[md5sum] = "665d70f18058a3196e6f6d4acea39ab4"
SRC_URI[sha256sum] = "8df99b9552a0e18bfdae5fd8c50dc58e1c8bebe7c690f17157b8793ef5c8df39"

NPM_PKGNAME = "fn-name"

inherit npmhelper
inherit native
