SUMMARY = "NPM: acorn-jsx"
DESCRIPTION = "Modern, fast React.js JSX parser"
HOMEPAGE = "https://github.com/acornjs/acorn-jsx"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d31df94bc162bf7b3c8f6cc547294075"

SRC_URI = "https://registry.npmjs.org/acorn-jsx/-/acorn-jsx-5.2.0.tgz"
SRC_URI[md5sum] = "79c4cc6a0b0d13cc83f0eeda71c59dce"
SRC_URI[sha256sum] = "18e2e3494f7056b8930318291e0e2219da8ca5b253baa618df8a0d93ad2ca320"

NPM_PKGNAME = "acorn-jsx"

inherit npmhelper
inherit native
