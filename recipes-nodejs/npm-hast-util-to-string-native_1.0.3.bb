SUMMARY = "NPM: hast-util-to-string"
DESCRIPTION = "hast utility to get the plain-text value of a node"
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://readme.md;beginline=53;endline=54;md5=f7cd6e61bbbca39fe0e60b4899302d5a"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/hast-util-to-string/-/hast-util-to-string-1.0.3.tgz"
SRC_URI[md5sum] = "7612b5de9b8108fecb93b2bfc5690323"
SRC_URI[sha256sum] = "b15dcca2e10a063b3bba861c32bb771adcf62317c598a943d80150471eb823df"

NPM_PKGNAME = "hast-util-to-string"

inherit npmhelper
inherit native
