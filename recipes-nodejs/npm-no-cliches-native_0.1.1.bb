SUMMARY = "NPM: no-cliches"
DESCRIPTION = "Find clichés in your writings"
HOMEPAGE = "https://github.com/duereg/no-cliches"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ad1ea741b5c8f9d521103277c196d2dd"

SRC_URI = "https://registry.npmjs.org/no-cliches/-/no-cliches-0.1.1.tgz"
SRC_URI[md5sum] = "3da7989ba090b3e482e0f70302b69024"
SRC_URI[sha256sum] = "4eefbd6790b2917431d2ceda460e74f321e736f4018da9053d252ef8f8a05bbd"

NPM_PKGNAME = "no-cliches"

inherit npmhelper
inherit native
