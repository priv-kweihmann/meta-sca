SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.2.4.tgz"
SRC_URI[md5sum] = "2857935139ed0925198b5db2b721a497"
SRC_URI[sha256sum] = "fb2d1fd81e719c7bd074e175a03d93b385a2e6555c8c19d5fffbf76a257be4a5"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
