SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.0.3.tgz"
SRC_URI[md5sum] = "ccb22003b7016cb1f15da34017462c36"
SRC_URI[sha256sum] = "62e23c2189f862501f9f38d12eac27209a94af781a1c938b7792823df787b72e"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
