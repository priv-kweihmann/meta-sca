SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-2.1.1.tgz"
SRC_URI[md5sum] = "13942b7b16eb42badbb3f82f50554b37"
SRC_URI[sha256sum] = "56413e3b026e0d8f919fe059b544c2ccf212cc12a798bf2e11221c84c04848ce"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
