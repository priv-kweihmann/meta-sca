SUMMARY = "NPM: indent-string"
DESCRIPTION = "Indent each line in a string"
HOMEPAGE = "https://github.com/sindresorhus/indent-string#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

SRC_URI = "https://registry.npmjs.org/indent-string/-/indent-string-4.0.0.tgz"
SRC_URI[md5sum] = "ad188c269f2d9181da4321f8803a4cde"
SRC_URI[sha256sum] = "bc6b74d3d74eb341c8b590c697c7fcd259c6fd1223c4b44dbfb11887ce9842a0"

NPM_PKGNAME = "indent-string"

inherit npmhelper
inherit native
