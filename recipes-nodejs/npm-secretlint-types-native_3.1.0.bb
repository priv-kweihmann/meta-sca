SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-3.1.0.tgz"
SRC_URI[md5sum] = "0d5ab4ce0cd08b7a9de22e2b73f53c88"
SRC_URI[sha256sum] = "2efbb820781ea33c3c843ea88a5402c866882d60e708ce86b57a6644d2153851"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
