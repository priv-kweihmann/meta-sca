SUMMARY = "NPM: get-own-enumerable-property-symbols"
DESCRIPTION = "Returns an array of all enumerable symbol properties found directly upon a given object"
HOMEPAGE = "https://github.com/mightyiam/get-own-enumerable-property-symbols#readme"

LICENSE = "ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=53133536e4534f040fb03df20d67e286"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/get-own-enumerable-property-symbols/-/get-own-enumerable-property-symbols-3.0.2.tgz"
SRC_URI[md5sum] = "444ae7447fc5986f6e5a738e7c21df04"
SRC_URI[sha256sum] = "bbe13b183477c86de82cefe8eea81424ac2efd7486c008c9e6f1653667262054"

NPM_PKGNAME = "get-own-enumerable-property-symbols"

inherit npmhelper
inherit native
