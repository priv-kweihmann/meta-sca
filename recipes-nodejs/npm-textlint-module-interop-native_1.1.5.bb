SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.1.5.tgz"
SRC_URI[md5sum] = "058ec2d7173a56aec925d3f05553d425"
SRC_URI[sha256sum] = "d37d888282b704480c8232998af114df3e364a67dbaa622cfff4cb2a185990b0"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
