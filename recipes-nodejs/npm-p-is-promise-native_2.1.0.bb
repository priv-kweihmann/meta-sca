SUMMARY = "NPM: p-is-promise"
DESCRIPTION = "Check if something is a promise"
HOMEPAGE = "https://github.com/sindresorhus/p-is-promise#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

SRC_URI = "https://registry.npmjs.org/p-is-promise/-/p-is-promise-2.1.0.tgz"
SRC_URI[md5sum] = "7fb3c5519d3e0fcf7f8d6faedef246db"
SRC_URI[sha256sum] = "ceaa18b2242baecc86bb83e7257fbc8c612386c4a7ff1dc74ca63e246703d345"

NPM_PKGNAME = "p-is-promise"

inherit npmhelper
inherit native
