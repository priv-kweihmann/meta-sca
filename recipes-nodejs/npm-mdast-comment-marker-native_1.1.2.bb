SUMMARY = "NPM: mdast-comment-marker"
DESCRIPTION = "mdast utility to parse a comment marker"
HOMEPAGE = "https://github.com/syntax-tree/mdast-comment-marker#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/mdast-comment-marker/-/mdast-comment-marker-1.1.2.tgz"
SRC_URI[md5sum] = "6c2191714e6a2d394be64ada068bfeef"
SRC_URI[sha256sum] = "b1fecd7e770b0bf72044987297982d55195d3a481ca717d15ef6d6f6f674238b"

NPM_PKGNAME = "mdast-comment-marker"

inherit npmhelper
inherit native
