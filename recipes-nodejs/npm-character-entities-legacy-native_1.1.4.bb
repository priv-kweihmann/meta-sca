SUMMARY = "NPM: character-entities-legacy"
DESCRIPTION = "HTML legacy character entity information"
HOMEPAGE = "https://github.com/wooorm/character-entities-legacy#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/character-entities-legacy/-/character-entities-legacy-1.1.4.tgz"
SRC_URI[md5sum] = "0a0fdd6abc10fc5c760966c67d0956cf"
SRC_URI[sha256sum] = "c499354876217da41eb2b853b2fff68dbb6e6b39881043cc16dacc3847cac75a"

NPM_PKGNAME = "character-entities-legacy"

inherit npmhelper
inherit native
