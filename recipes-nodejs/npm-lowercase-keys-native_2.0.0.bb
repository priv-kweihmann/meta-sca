SUMMARY = "NPM: lowercase-keys"
DESCRIPTION = "Lowercase the keys of an object"
HOMEPAGE = "https://github.com/sindresorhus/lowercase-keys#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/lowercase-keys/-/lowercase-keys-2.0.0.tgz"
SRC_URI[md5sum] = "f97b6bfcea219dbc8c1e68ce04f5552e"
SRC_URI[sha256sum] = "43c680c2633b9259ef6b27fc233ec01589b0c684d20a0a34e230fc7faa703b51"

NPM_PKGNAME = "lowercase-keys"

inherit npmhelper
inherit native
