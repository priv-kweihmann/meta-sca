SUMMARY = "NPM: character-reference-invalid"
DESCRIPTION = "HTML invalid numeric character reference information"
HOMEPAGE = "https://github.com/wooorm/character-reference-invalid#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/character-reference-invalid/-/character-reference-invalid-2.0.0.tgz"
SRC_URI[md5sum] = "1ad588b82a6731129e9fa3332d085714"
SRC_URI[sha256sum] = "4fc1e23acd2e8a6bd83844fc858705ca9091f6c51b7a73307e3fe1ce4879988a"

NPM_PKGNAME = "character-reference-invalid"

inherit npmhelper
inherit native
