SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.2.3.tgz"
SRC_URI[md5sum] = "87dc16f5e03c00939e29d16490fcf3d3"
SRC_URI[sha256sum] = "ea0212681b27301ab15c02753e11c346371bb36e7d377b6b577d38ec04500aea"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
