SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.13.8.tgz"
SRC_URI[md5sum] = "b4c154297abe5f042a3f655799f91bc0"
SRC_URI[sha256sum] = "78939e160a174426871ebd6437d88f79251e8cf4b0f2715e65e94c5f1f340adb"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
