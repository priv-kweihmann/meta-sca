SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.2.2.tgz"
SRC_URI[md5sum] = "69fbe96b40791cb354b05c7983eefde1"
SRC_URI[sha256sum] = "2b5b4fe5b286834b4959c4a8da11166935666066a53c874aea061941ef9f84f3"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
