SUMMARY = "NPM: p-cancelable"
DESCRIPTION = "Create a promise that can be canceled"
HOMEPAGE = "https://github.com/sindresorhus/p-cancelable#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=d5f2a6dd0192dcc7c833e50bb9017337"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/p-cancelable/-/p-cancelable-3.0.0.tgz"
SRC_URI[md5sum] = "b362446f8e050097445a548629d104b5"
SRC_URI[sha256sum] = "55939c31dc486d6b92f42dbe932bad9602e395aa052fc7b5dfcffe73f4673f34"

NPM_PKGNAME = "p-cancelable"

inherit npmhelper
inherit native
