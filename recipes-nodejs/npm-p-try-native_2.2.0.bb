SUMMARY = "NPM: p-try"
DESCRIPTION = "`Start a promise chain"
HOMEPAGE = "https://github.com/sindresorhus/p-try#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

SRC_URI = "https://registry.npmjs.org/p-try/-/p-try-2.2.0.tgz"
SRC_URI[md5sum] = "49994562e1f3cbe260710598cbb3edf7"
SRC_URI[sha256sum] = "a390b2b89899df950afc0304eaba7cd1f5e3746b2e370758a9b50f177e713790"

NPM_PKGNAME = "p-try"

inherit npmhelper
inherit native
