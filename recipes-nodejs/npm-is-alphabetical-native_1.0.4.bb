SUMMARY = "NPM: is-alphabetical"
DESCRIPTION = "Check if a character is alphabetical"
HOMEPAGE = "https://github.com/wooorm/is-alphabetical#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

SRC_URI = "https://registry.npmjs.org/is-alphabetical/-/is-alphabetical-1.0.4.tgz"
SRC_URI[md5sum] = "de1336fee89176bb96dac03e89759975"
SRC_URI[sha256sum] = "d2663180b8954a9f0f73551b100f49b3502660b0ee2da23a54790c068ca3bc5b"

NPM_PKGNAME = "is-alphabetical"

inherit npmhelper
inherit native
