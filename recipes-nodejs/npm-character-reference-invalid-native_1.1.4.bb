SUMMARY = "NPM: character-reference-invalid"
DESCRIPTION = "HTML invalid numeric character reference information"
HOMEPAGE = "https://github.com/wooorm/character-reference-invalid#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

SRC_URI = "https://registry.npmjs.org/character-reference-invalid/-/character-reference-invalid-1.1.4.tgz"
SRC_URI[md5sum] = "f480e6f17787cb849356fc5590eb8b0e"
SRC_URI[sha256sum] = "a8634df7c57d19a2282b20d3672079e329d74f88598605fed573354ef18b61c4"

NPM_PKGNAME = "character-reference-invalid"

inherit npmhelper
inherit native
