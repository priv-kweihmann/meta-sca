SUMMARY = "NPM: nlcst-to-string"
DESCRIPTION = "nlcst utility to transform a tree to a string"
HOMEPAGE = "https://github.com/syntax-tree/nlcst-to-string#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=f94eeeb01d2350e09cda730abca93641"

SRC_URI = "https://registry.npmjs.org/nlcst-to-string/-/nlcst-to-string-2.0.4.tgz"
SRC_URI[md5sum] = "507209bb7526f077a71feae1968f6297"
SRC_URI[sha256sum] = "45b2da5b4ca0bb4f73dbd9bc9d40ebb70783160078a6a9869cecddfbcc7d91ab"

NPM_PKGNAME = "nlcst-to-string"

inherit npmhelper
inherit native
