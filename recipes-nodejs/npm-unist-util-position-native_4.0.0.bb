SUMMARY = "NPM: unist-util-position"
DESCRIPTION = "unist utility to get the position of a node"
HOMEPAGE = "https://github.com/syntax-tree/unist-util-position#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=91fb5297439b32d9cd49df8a2484d3eb"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/unist-util-position/-/unist-util-position-4.0.0.tgz"
SRC_URI[md5sum] = "df5cbe503a406652de1865e1ac9f5c6d"
SRC_URI[sha256sum] = "2f49bf327f82279ef8eacf8e203392ea8c329e525d7fa859454859a93e18e47e"

NPM_PKGNAME = "unist-util-position"

inherit npmhelper
inherit native
