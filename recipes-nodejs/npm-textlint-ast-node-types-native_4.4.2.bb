SUMMARY = "NPM: @textlint/ast-node-types"
DESCRIPTION = "textlint AST node type definition."
HOMEPAGE = "https://github.com/textlint/textlint#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3452a94937d21f84bc38880f636e3ba"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/ast-node-types/-/ast-node-types-4.4.2.tgz"
SRC_URI[md5sum] = "ef3f68b7cae744b31a19aadd382e2adc"
SRC_URI[sha256sum] = "d87a429bad6b9b130abdd559ad3af97ce52b4dc752f385a1572830e9797ac814"

NPM_PKGNAME = "@textlint/ast-node-types"

inherit npmhelper
inherit native
