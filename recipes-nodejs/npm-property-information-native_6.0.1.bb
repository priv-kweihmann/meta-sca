SUMMARY = "NPM: property-information"
DESCRIPTION = "Information for HTML properties"
HOMEPAGE = "https://github.com/wooorm/property-information#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=7e5307a85144ae88c8ce8eb803918a97"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/property-information/-/property-information-6.0.1.tgz"
SRC_URI[md5sum] = "b82d6cd1a78b04069d610499a23744d7"
SRC_URI[sha256sum] = "568d6b0e40816bfa5cea16e521b27e4137fa7a0dadee95a056880d4d02e2ccec"

NPM_PKGNAME = "property-information"

inherit npmhelper
inherit native
