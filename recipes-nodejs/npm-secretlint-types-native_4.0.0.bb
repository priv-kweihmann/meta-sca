SUMMARY = "NPM: @secretlint/types"
DESCRIPTION = "A typing package for @secretlint"
HOMEPAGE = "https://github.com/secretlint/secretlint/tree/master/packages/@secretlint/types/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=402802be77c922cb018a8b5099208dab"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@secretlint/types/-/types-4.0.0.tgz"
SRC_URI[md5sum] = "6bbba73bb4a173e88524c9c098850776"
SRC_URI[sha256sum] = "b0cbf946cc0e4456f683ae93d7e793826ddd377dbc0fdd4ea5d3c7f72771b0ca"

NPM_PKGNAME = "@secretlint/types"

inherit npmhelper
inherit native
