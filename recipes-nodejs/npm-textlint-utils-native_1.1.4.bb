SUMMARY = "NPM: @textlint/utils"
DESCRIPTION = "textlint internal utils."
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/utils/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/utils/-/utils-1.1.4.tgz"
SRC_URI[md5sum] = "defac5076e506d9d60c5c3a8589c31d0"
SRC_URI[sha256sum] = "d572ca9b1cab077acfaa590db60889d91a5ee5c53de5ab9147be617be964d0e9"

NPM_PKGNAME = "@textlint/utils"

inherit npmhelper
inherit native
