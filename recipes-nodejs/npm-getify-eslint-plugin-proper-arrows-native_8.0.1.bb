SUMMARY = "NPM: @getify/eslint-plugin-proper-arrows"
DESCRIPTION = "ESLint rules to ensure proper arrow function definitions"
HOMEPAGE = "https://github.com/getify/eslint-plugin-proper-arrows"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=1d94c8e9d6efb6e3b31b75ff3c6fe905"

SRC_URI = "https://registry.npmjs.org/@getify/eslint-plugin-proper-arrows/-/eslint-plugin-proper-arrows-8.0.1.tgz"
SRC_URI[md5sum] = "926bbe266239a4abee9359fd3309772d"
SRC_URI[sha256sum] = "d5791a85e5b414f8789d688f7e013bdbc02c13050d30a4127b01daf737405b20"

NPM_PKGNAME = "@getify/eslint-plugin-proper-arrows"

inherit npmhelper
inherit native
