SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.13.6.tgz"
SRC_URI[md5sum] = "02816f3ecfee000c61c8315aaa2e5825"
SRC_URI[sha256sum] = "2c16f83bead23489a4a4b96a26a53d646af9623a1a2a0a30cbb0e831941ff3fd"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
