SUMMARY = "NPM: is-fullwidth-code-point"
DESCRIPTION = "Check if the character represented by a given Unicode code point is fullwidth"
HOMEPAGE = "https://github.com/sindresorhus/is-fullwidth-code-point#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

SRC_URI = "https://registry.npmjs.org/is-fullwidth-code-point/-/is-fullwidth-code-point-3.0.0.tgz"
SRC_URI[md5sum] = "87c5848714e5ed8e25abbdc13cfe3995"
SRC_URI[sha256sum] = "6f415dae5dc6070f1b42daee6165eab941a97101982305facc8bafdaf300bc4a"

NPM_PKGNAME = "is-fullwidth-code-point"

inherit npmhelper
inherit native
