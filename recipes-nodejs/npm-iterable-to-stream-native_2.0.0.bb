SUMMARY = "NPM: iterable-to-stream"
DESCRIPTION = "Converts iterable objects into readable streams."
HOMEPAGE = "https://github.com/Jason3S/iterable-to-stream#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d6c2f216355cbd3a4d1d54e29f56a409"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/iterable-to-stream/-/iterable-to-stream-2.0.0.tgz"
SRC_URI[md5sum] = "f733d078b0ba32e36dea90d7f44e2041"
SRC_URI[sha256sum] = "e73537cdc57e80e58b0a11b2e5a11365ab2b22afdf24205b7f4db81735f3bf95"

NPM_PKGNAME = "iterable-to-stream"

inherit npmhelper
inherit native
