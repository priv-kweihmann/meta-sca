SUMMARY = "NPM: @babel/compat-data"
DESCRIPTION = ""
HOMEPAGE = "{homepage}"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b1d0cd283a346e919abb3beeb018279d"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@babel/compat-data/-/compat-data-7.15.0.tgz"
SRC_URI[md5sum] = "6cc93e31eb620eb09f9679b2b2dcc8cd"
SRC_URI[sha256sum] = "56f29f80eaf4b4037bf9c5f65b1924af35c7024dace87856994dac626e533b0c"

NPM_PKGNAME = "@babel/compat-data"

inherit npmhelper
inherit native
