SUMMARY = "NPM: is-hexadecimal"
DESCRIPTION = "Check if a character is hexadecimal"
HOMEPAGE = "https://github.com/wooorm/is-hexadecimal#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/is-hexadecimal/-/is-hexadecimal-2.0.0.tgz"
SRC_URI[md5sum] = "8be95de41d34d64b638927f3d9d0685d"
SRC_URI[sha256sum] = "220921b6d0d2399b60465430a6e5ae6c5999698e946ca80bc43eeef35148b5b8"

NPM_PKGNAME = "is-hexadecimal"

inherit npmhelper
inherit native
