SUMMARY = "NPM: space-separated-tokens"
DESCRIPTION = "Parse and stringify space-separated tokens"
HOMEPAGE = "https://github.com/wooorm/space-separated-tokens#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=8e9f707ac01af145c36ef2adde15d7e4"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/space-separated-tokens/-/space-separated-tokens-1.1.5.tgz"
SRC_URI[md5sum] = "404950759620f804f57ae419f1158d2c"
SRC_URI[sha256sum] = "25344b42857480f05fb432debe4eefd40fe9894b57df448b9768df0a1c99fec3"

NPM_PKGNAME = "space-separated-tokens"

inherit npmhelper
inherit native
