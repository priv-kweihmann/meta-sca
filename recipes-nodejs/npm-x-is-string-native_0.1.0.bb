SUMMARY = "NPM: x-is-string"
DESCRIPTION = "Simple string test"
HOMEPAGE = "https://github.com/Matt-Esch/x-is-string"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENCE;md5=1231f59990a57e45386b38df7d068280"

SRC_URI = "https://registry.npmjs.org/x-is-string/-/x-is-string-0.1.0.tgz"
SRC_URI[md5sum] = "7ce169611f631529e2641b65467764c6"
SRC_URI[sha256sum] = "2757a91fd45245a89c7492d0a29e4f949f2928e93478aaed653392b89fb8b2e8"

NPM_PKGNAME = "x-is-string"

inherit npmhelper
inherit native
