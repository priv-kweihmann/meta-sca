SUMMARY = "NPM: cli-boxes"
DESCRIPTION = "Boxes for use in the terminal"
HOMEPAGE = "https://github.com/sindresorhus/cli-boxes"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=a12ebca0510a773644101a99a867d210"

SRC_URI = "https://registry.npmjs.org/cli-boxes/-/cli-boxes-1.0.0.tgz"
SRC_URI[md5sum] = "ab4bc1c90f9c5ad63a6e960c903186f7"
SRC_URI[sha256sum] = "98111d24fa9bd9a60255b0f5d4f54ee2fc749dfbd88b0db2523db4e27e2f9187"

NPM_PKGNAME = "cli-boxes"

inherit npmhelper
inherit native
