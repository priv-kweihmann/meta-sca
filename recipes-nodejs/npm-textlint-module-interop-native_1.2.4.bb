SUMMARY = "NPM: @textlint/module-interop"
DESCRIPTION = "ECMAScript module interop library"
HOMEPAGE = "https://github.com/textlint/textlint/tree/master/packages/@textlint/module-interop/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fdf16298bf702d1ba5d61988dfe70c9f"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/@textlint/module-interop/-/module-interop-1.2.4.tgz"
SRC_URI[md5sum] = "9f69de83643e02e65160ec91fc2a2b0f"
SRC_URI[sha256sum] = "8bc37a82666a9194c2a2d2b22e953fe8a96acf106a9cc2f573b3ad0dd9908bc1"

NPM_PKGNAME = "@textlint/module-interop"

inherit npmhelper
inherit native
