SUMMARY = "NPM: ret"
DESCRIPTION = "Tokenizes a string that represents a regular expression."
HOMEPAGE = "https://github.com/fent/ret.js#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=9aeada1cccf95163778a1c8189c8f297"

SRC_URI = "https://registry.npmjs.org/ret/-/ret-0.1.15.tgz"
SRC_URI[md5sum] = "f4e653f5e9d5d653db6c881b71e7ec0a"
SRC_URI[sha256sum] = "4a7462b50b3184e14d3518cc0438624ad20aa21bafeb30568aede82f07ef69fe"

NPM_PKGNAME = "ret"

inherit npmhelper
inherit native
