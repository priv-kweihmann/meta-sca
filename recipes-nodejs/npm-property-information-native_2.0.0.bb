SUMMARY = "NPM: property-information"
DESCRIPTION = "Information for HTML properties"
HOMEPAGE = "https://github.com/wooorm/property-information#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7e5307a85144ae88c8ce8eb803918a97"

SRC_URI = "https://registry.npmjs.org/property-information/-/property-information-2.0.0.tgz"
SRC_URI[md5sum] = "80afc319bb7fec0410864cba6b7e81df"
SRC_URI[sha256sum] = "b81fab08e0ed19ff13ad2deee871a8961c21ac507e350d77b9f87cf6c3c08d44"

NPM_PKGNAME = "property-information"

inherit npmhelper
inherit native
