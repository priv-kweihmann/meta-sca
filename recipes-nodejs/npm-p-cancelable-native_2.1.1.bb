SUMMARY = "NPM: p-cancelable"
DESCRIPTION = "Create a promise that can be canceled"
HOMEPAGE = "https://github.com/sindresorhus/p-cancelable#readme"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://license;md5=915042b5df33c31a6db2b37eadaa00e3"

DEPENDS = ""

SRC_URI = "https://registry.npmjs.org/p-cancelable/-/p-cancelable-2.1.1.tgz"
SRC_URI[md5sum] = "e270d3b46c3c33ece984b27cc140e652"
SRC_URI[sha256sum] = "90b27023c7008f572240c117c23b92933743a4da50419a3724b91c4ec79040d0"

NPM_PKGNAME = "p-cancelable"

inherit npmhelper
inherit native
