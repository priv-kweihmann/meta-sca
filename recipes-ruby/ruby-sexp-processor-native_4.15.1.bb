SUMMARY = "branches from ParseTree bringing all the generic sexp processing tools"
HOMEPAGE = "https://github.com/seattlerb/sexp_processor"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rdoc;beginline=72;md5=b3e341281591d1a60de96a4508ad2e69"

SRC_URI[md5sum] = "40a09d88260dd5cf966e0b235fe72b51"
SRC_URI[sha256sum] = "9291a0f2247f50d15068ee6965b67cd7b678b0d273e18adf3c0b2ea4a890125c"

GEM_NAME = "sexp_processor"

inherit rubygemsnative
