SUMMARY = "RubyGem: tty-color"
DESCRIPTION = "Terminal color capabilities detection"
HOMEPAGE = "https://ttytoolkit.org"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6720614e0c073da535307bdc70034e9c"

DEPENDS = ""
RDEPENDS_${PN} += ""

SRC_URI[md5sum] = "c07b77abb865c0ad470217431d07bb89"
SRC_URI[sha256sum] = "6f9c37ca3a4e2367fb2e6d09722762647d6f455c111f05b59f35730eeb24332a"

GEM_NAME = "tty-color"

inherit rubygems
