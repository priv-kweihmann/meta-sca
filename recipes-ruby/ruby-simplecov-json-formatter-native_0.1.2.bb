SUMMARY = "JSON formatter for SimpleCov"
HOMEPAGE = "https://github.com/fede-moya/simplecov_json_formatter"

LICENSE = "MIT"
# does not provide a license file
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[md5sum] = "f2a81a45c4bf7caf628f4f3e080f2c09"
SRC_URI[sha256sum] = "d23cd340bc10d78c11f874a99ed233bdb01a111b46edd075d7079735ee918332"

GEM_NAME = "simplecov_json_formatter"

inherit rubygemsnative
