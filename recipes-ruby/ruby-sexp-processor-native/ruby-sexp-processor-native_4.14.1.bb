SUMMARY = "branches from ParseTree bringing all the generic sexp processing tools"
HOMEPAGE = "https://github.com/seattlerb/sexp_processor"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rdoc;beginline=72;md5=b3e341281591d1a60de96a4508ad2e69"

SRC_URI[md5sum] = "994c7ba7bbf45d6f1ae5b6b32edc8624"
SRC_URI[sha256sum] = "0fa8731445cf4a0c01570ec29aac4b50a0451ce66b1b31ad768f5035e3af7b90"

GEM_NAME = "sexp_processor"

inherit sca-sanity
inherit rubygemsnative
