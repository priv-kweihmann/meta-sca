SUMMARY = "branches from ParseTree bringing all the generic sexp processing tools"
HOMEPAGE = "https://github.com/seattlerb/sexp_processor"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rdoc;beginline=72;md5=b3e341281591d1a60de96a4508ad2e69"

SRC_URI[md5sum] = "d58bb5a1334f34bb8e0db83b43fd59a8"
SRC_URI[sha256sum] = "a5ec27d8055ad47444cfb7ce860bad8af2365772a82892f4a8a0d97e8e9e3b34"

GEM_NAME = "sexp_processor"

inherit rubygemsnative
