SUMMARY = "Colorize printed text on ANSI terminals"
HOMEPAGE = "https://github.com/sickill/rainbow"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b3dd1cdfc682803de86f82b443bcd3"

SRC_URI[md5sum] = "a4959de1d41c77d25eb56dbeeb37cf39"
SRC_URI[sha256sum] = "13ce4ffc3c94fb7a842117ecabdcdc5ff7fa27bec15ea44137b9f9abe575622d"

GEM_NAME = "rainbow"

inherit rubygemsnative
