SUMMARY = "Docile treats the methods of a given ruby object as a DSL"
HOMEPAGE = "https://github.com/ms-ati/docile"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2a7124ad8a19d24c885fb23156fdea91"

SRC_URI[md5sum] = "b1715b1027b78318749264a0e3f6a36a"
SRC_URI[sha256sum] = "2e3eb481209795084eaf3a8b55e35991048abc02cba9363afd88fefe948f3c63"

GEM_NAME = "docile"

inherit rubygemsnative
