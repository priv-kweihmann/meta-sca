SUMMARY = "RubyGem: declarative-option"
DESCRIPTION = "Dynamic options."
HOMEPAGE = "https://github.com/apotonick/declarative-option"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6bdd96db3845e32cb1f0234df032a60"

DEPENDS += ""
RDEPENDS_${PN} += ""

SRC_URI[md5sum] = "a8e567febc10559e3052485682d23bac"
SRC_URI[sha256sum] = "b6589cbc619199217768acce28690ba8323575efa2300940c48456129acc6a73"

GEM_NAME = "declarative-option"

inherit rubygems
