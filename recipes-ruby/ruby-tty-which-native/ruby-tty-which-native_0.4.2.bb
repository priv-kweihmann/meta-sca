SUMMARY = "Platform independent implementation of Unix which command"
HOMEPAGE = "https://github.com/piotrmurach/tty-which"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=c9f5a91217b4b11751b2084dda90ff19"

SRC_URI[md5sum] = "2418a6f6dbe3eda6d1af13c11b3e4f3e"
SRC_URI[sha256sum] = "0ac45f416555041882c632602aeb733379fec08b08a3123d92e78283741823ce"

GEM_NAME = "tty-which"

inherit rubygemsnative
