SUMMARY = "Kwalify is a parser, schema validator, and data binding tool for YAML and JSON."
HOMEPAGE = "http://www.kuwata-lab.com/kwalify/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://MIT-LICENSE;md5=a117fe398d6b4c0f083f73459da1bae2"

SRC_URI[md5sum] = "54e03aa70a07a8cb6941fa191e5176a8"
SRC_URI[sha256sum] = "4eee60e7dc2c4f182af30e1a64639bc1787a985462b4615bba7117acfd78fdd9"

GEM_NAME = "kwalify"

inherit rubygems
inherit native
