SUMMARY = "A library for working with Abstract Syntax Trees"
HOMEPAGE = "https://github.com/whitequark/ast/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.MIT;md5=b46ff44655f29020fc7542adda3ad781"

SRC_URI[md5sum] = "d361b241a0dcd72b7f791227b6ce4cbd"
SRC_URI[sha256sum] = "4a54905a05a3ae848ec67d81a79625b77b92feb91090ab46a2bdcaff193264d0"

GEM_NAME = "ast"

inherit rubygemsnative
