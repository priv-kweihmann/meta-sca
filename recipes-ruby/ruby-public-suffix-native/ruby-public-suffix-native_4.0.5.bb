SUMMARY = "PublicSuffix can parse and decompose a domain name"
HOMEPAGE = "https://simonecarletti.com/code/publicsuffix-ruby"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4c89161c761aa8e9188cee9f19125f9c"

SRC_URI[md5sum] = "fe7579f10c7817f06699f6a0b68e8767"
SRC_URI[sha256sum] = "efbc976b8f8cd7e2f9387b41ad4dc5447bcc7e862cf3afd909f13b0048a3dc6f"

GEM_NAME = "public_suffix"

inherit rubygemsnative
