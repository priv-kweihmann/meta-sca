SUMMARY = "PublicSuffix can parse and decompose a domain name"
HOMEPAGE = "https://simonecarletti.com/code/publicsuffix-ruby"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4c89161c761aa8e9188cee9f19125f9c"

SRC_URI[md5sum] = "800cf05cf3d85b107b4824bde95b0089"
SRC_URI[sha256sum] = "3ff2a10253583b2780b6fb0ea643a2e877ae3bf719bd987fe5f16b550ec733d0"

GEM_NAME = "public_suffix"

inherit rubygemsnative
