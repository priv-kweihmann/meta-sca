SUMMARY = "RubyGem: declarative-option"
DESCRIPTION = "Dynamic options."
HOMEPAGE = "https://github.com/apotonick/declarative-option"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6bdd96db3845e32cb1f0234df032a60"

DEPENDS = ""
RDEPENDS_${PN} += ""

SRC_URI[md5sum] = "da8363773bbe1dc01ab3fc308aa32423"
SRC_URI[sha256sum] = "17508349f51c5631e5ad4158c29f78a4b2de618abffa066d76c11953705f91bc"

GEM_NAME = "declarative-option"

inherit rubygems
