SUMMARY = "Thread-safe collections for Ruby"
DESCRIPTION = "A collection of data structures and utilities to make thread-safe programming in Ruby easier"
HOMEPAGE = "https://github.com/ruby-concurrency/thread_safe"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c3e1c339f1d1a0d93fbe01b8dab347ef"

SRC_URI[md5sum] = "ccceb766849c53ed7cf9b5e25191cbcb"
SRC_URI[sha256sum] = "9ed7072821b51c57e8d6b7011a8e282e25aeea3a4065eab326e43f66f063b05a"

GEM_NAME = "thread_safe"

inherit rubygemsnative
