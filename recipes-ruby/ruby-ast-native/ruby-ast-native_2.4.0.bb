SUMMARY = "A library for working with Abstract Syntax Trees"
HOMEPAGE = "https://github.com/whitequark/ast/"

LICENSE = "MIT"
LIC_FILES_CHKSUM  = "file://LICENSE.MIT;md5=b46ff44655f29020fc7542adda3ad781"

SRC_URI[md5sum] = "32de813722684ea1dad7fefc676d0838"
SRC_URI[sha256sum] = "a7270b78d8c970e90a5b932471c691e3ca74aa8be030f1a954d38ec487d79aa0"

GEM_NAME = "ast"

inherit sca-sanity
inherit rubygemsnative
