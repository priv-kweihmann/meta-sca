SUMMARY = "Deep Freeze Ruby Objects"
HOMEPAGE = "https://github.com/dkubb/ice_nine"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=957c3fa8227461c40374691312e5e454"

SRC_URI[md5sum] = "4b7032c80c422e45cdd614e066f3b8b6"
SRC_URI[sha256sum] = "5d506a7d2723d5592dc121b9928e4931742730131f22a1a37649df1c1e2e63db"

GEM_NAME = "ice_nine"

inherit rubygemsnative
