SUMMARY = "PathExpander helps pre-process command-line arguments"
HOMEPAGE = "https://github.com/seattlerb/path_expander"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rdoc;beginline=53;md5=b3e341281591d1a60de96a4508ad2e69"

SRC_URI[md5sum] = "dcf4aae5c127cfd3ecc2f5271c13c5f8"
SRC_URI[sha256sum] = "fb81a1f665f17579f8b450412e79009809584e25dab154cb5c88a59222b280d0"

GEM_NAME = "path_expander"

inherit rubygemsnative
