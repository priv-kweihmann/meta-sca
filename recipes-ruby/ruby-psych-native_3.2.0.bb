SUMMARY = "Psych is a YAML parser and emitter."
HOMEPAGE = "https://github.com/ruby/psych"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6049ec73dcc7c3993367081b94cbd00a"

SRC_URI[md5sum] = "ba06cfef0c10354a9be1a147fedb9789"
SRC_URI[sha256sum] = "b896027249300cbc15e03c64a28fef6983458c572306bb86326d27394faf8e39"

GEM_NAME = "psych"

inherit rubygemsnative
