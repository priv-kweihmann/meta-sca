SUMMARY = "RubyGem: nori"
DESCRIPTION = "XML to Hash translator"
HOMEPAGE = "https://github.com/savonrb/nori"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c6f524fd55eb30137bfb7f40fae63208"

DEPENDS = ""
RDEPENDS_${PN} += ""

SRC_URI[md5sum] = "dc9c83026c10a3eb7093b9c8208c84f7"
SRC_URI[sha256sum] = "f629a4e92fe394e78f9441d55e71f5606ce8c045f3cc81f326f70b45ce61dc18"

GEM_NAME = "nori"

inherit rubygems
