SUMMARY = "RubyGem: declarative"
DESCRIPTION = "DSL for nested generic schemas with inheritance and refining."
HOMEPAGE = "https://github.com/apotonick/declarative"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5602ce7d3013a7d27bcc24b83a3c7309"

DEPENDS = ""
RDEPENDS_${PN} += ""

SRC_URI[md5sum] = "03d8463ba50f6979b0718934247badc2"
SRC_URI[sha256sum] = "8021dd6cb17ab2b61233c56903d3f5a259c5cf43c80ff332d447d395b17d9ff9"

GEM_NAME = "declarative"

inherit rubygems
