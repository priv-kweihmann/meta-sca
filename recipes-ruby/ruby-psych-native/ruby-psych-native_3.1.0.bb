SUMMARY = "Psych is a YAML parser and emitter."
HOMEPAGE = "https://github.com/ruby/psych"

LICENSE = "MIT"
LIC_FILES_CHKSUM  = "file://README.md;beginline=57;md5=a65d46938ef6a78a9d3f607239e73d08"

SRC_URI[md5sum] = "ad4e39909685fa4e46426419ad019655"
SRC_URI[sha256sum] = "a858cf8d4bc636fd6dc635131c4df24d25da910278a873a0fbe4927d17155b26"

GEM_NAME = "psych"

inherit sca-sanity
inherit rubygemsnative
