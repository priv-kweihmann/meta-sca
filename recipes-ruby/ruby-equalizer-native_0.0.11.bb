SUMMARY = "Module to define equality, equivalence and inspection methods"
HOMEPAGE = "https://github.com/dkubb/equalizer"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91ed5f459e9d906d6b9b00c567d8dc19"

SRC_URI[md5sum] = "c1e314f1e4c659aebdf7c16892180b32"
SRC_URI[sha256sum] = "44e5bc46f49883e83d159ee9b1f7320b4ae8283bb6329e5d9716f5e7dde855ce"

GEM_NAME = "equalizer"

inherit rubygemsnative
