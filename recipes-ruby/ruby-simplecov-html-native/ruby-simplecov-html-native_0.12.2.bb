SUMMARY = "Default HTML formatter for SimpleCov code coverage tool"
HOMEPAGE = "https://github.com/colszowka/simplecov-html"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=23973b4bd84f8a5e081dd23bb739394d"

SRC_URI[md5sum] = "329df0d4bf56660b714cf6f2c9534a91"
SRC_URI[sha256sum] = "c9ae10b01a765452c9a50bedd3e8a20ee0f1793d9850f8c89e884b7b5c25ebec"

GEM_NAME = "simplecov-html"

inherit rubygemsnative
