inherit sca

## Limit the modules to a reasonable amount
SCA_ENABLED_MODULES = "\
    bashate \
    bitbake \
    checkbashism \
    kconfighard \
"
