inherit sca

SCA_AVAILABLE_MODULES = "splint"
