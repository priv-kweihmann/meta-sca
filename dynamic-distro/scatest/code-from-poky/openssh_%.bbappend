inherit sca
SCA_ENABLED_MODULES = "detectsecrets"
