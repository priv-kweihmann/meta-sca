inherit setuptools
require python-detect-secrets-native.inc