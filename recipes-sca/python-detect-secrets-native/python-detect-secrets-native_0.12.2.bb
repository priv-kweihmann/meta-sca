inherit setuptools
require python-detect-secrets-native.inc

SRC_URI[md5sum] = "8cfc4ed0b122b9a94063250883a56e32"
SRC_URI[sha256sum] = "5f607a043c3b9b6823774230155431e259e79490b3d31fa8c5105ab4c44256bc"
