inherit python-dir
require python-zeroresourcedetector-native.inc
