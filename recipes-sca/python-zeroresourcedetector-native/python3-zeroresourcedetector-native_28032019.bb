inherit python3-dir
require python-zeroresourcedetector-native.inc
