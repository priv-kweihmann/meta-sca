inherit setuptools3
require python-oelint-adv-native.inc
