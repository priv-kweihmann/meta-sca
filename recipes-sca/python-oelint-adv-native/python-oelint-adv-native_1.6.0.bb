inherit setuptools
require python-oelint-adv-native.inc
