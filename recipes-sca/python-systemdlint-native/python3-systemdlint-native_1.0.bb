inherit setuptools3
require python-systemdlint-native.inc
