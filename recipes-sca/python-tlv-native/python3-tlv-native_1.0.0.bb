inherit setuptools3
require python-tlv-native.inc
