inherit setuptools
require python-safety-native.inc

SRC_URI[md5sum] = "125e0a81b429acfcf0e4a6bcede8775b"
SRC_URI[sha256sum] = "5059f3ffab3648330548ea9c7403405bbfaf085b11235770825d14c58f24cb78"
