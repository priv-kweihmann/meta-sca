inherit python-dir
require python-pysymbolcheck-native.inc
