inherit setuptools3
require python-radon-native.inc

SRC_URI[md5sum] = "00d2dcc91783e28c240a8f64d917f27c"
SRC_URI[sha256sum] = "ee20308ce8bae7a89b067425b63b141a0077632ab318d5288da649c830882b3d"
