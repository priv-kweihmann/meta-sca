inherit setuptools
require python-dennis-native.inc

SRC_URI[md5sum] = "2636710455435f612e8595c659e2c746"
SRC_URI[sha256sum] = "8c942dd5da7d03c65daebc069c5ee5c7f1374ac9b0c8c89c627caa66fe822604"
