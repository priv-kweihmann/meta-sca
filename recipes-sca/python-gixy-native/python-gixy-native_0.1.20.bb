inherit setuptools
require python-gixy-native.inc