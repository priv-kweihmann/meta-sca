inherit setuptools
require python-ansiblelint-native.inc

SRC_URI[md5sum] = "309d06f0f215f0b63a5567b8e4f1a5b1"
SRC_URI[sha256sum] = "9430ea6e654ba4bf5b9c6921efc040f46cda9c4fd2896a99ff71d21037bcb123"
