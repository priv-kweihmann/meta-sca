inherit setuptools3
require python-ropgadget-native.inc
