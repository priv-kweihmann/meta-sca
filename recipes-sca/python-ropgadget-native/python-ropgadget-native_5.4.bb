inherit setuptools
require python-ropgadget-native.inc

SRC_URI[md5sum] = "9934f7afe3369376acb54e21e1fb528f"
SRC_URI[sha256sum] = "af37e327908796894928f0b3831008c7747d189812d37b4362e3e03a3af194a7"
