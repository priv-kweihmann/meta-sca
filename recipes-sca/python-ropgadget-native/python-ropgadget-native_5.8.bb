inherit setuptools
require python-ropgadget-native.inc
