inherit setuptools
require python-pylint-native.inc

SRC_URI[md5sum] = "8a9c0f6abdf90a1c802618b3c36986aa"
SRC_URI[sha256sum] = "ee1e85575587c5b58ddafa25e1c1b01691ef172e139fc25585e5d3f02451da93"
