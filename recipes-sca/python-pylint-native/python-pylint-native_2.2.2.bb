inherit setuptools
require python-pylint-native.inc

SRC_URI[md5sum] = "6bece9ce12a7461266ecc1908da8d492"
SRC_URI[sha256sum] = "689de29ae747642ab230c6d37be2b969bf75663176658851f456619aacf27492"
