inherit setuptools
require python-pyfindinjection-native.inc

SRC_URI[md5sum] = "5976a38bdc8d041e4c7724224d2fffd4"
SRC_URI[sha256sum] = "9c1bbd87f2da3c00580a99032b82ab91289b2d94098cbaee7fe2501db67a5c0e"
