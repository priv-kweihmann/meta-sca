inherit setuptools
require python-proselint-native.inc

SRC_URI[md5sum] = "68b800b5df2b98b2759087749eb88660"
SRC_URI[sha256sum] = "3a87eb393056d1bc77d898e4bcf8998f50e9ad84f7b9ff7cf2720509ac8ef904"
