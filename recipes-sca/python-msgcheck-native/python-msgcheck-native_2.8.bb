inherit setuptools
require python-msgcheck-native.inc

SRC_URI[md5sum] = "574e122bf964048155898cfcb185fc78"
SRC_URI[sha256sum] = "0aba4e5e3cd56685a3eff795f67c5c934c69161ae127674a3350b84939165d7a"
