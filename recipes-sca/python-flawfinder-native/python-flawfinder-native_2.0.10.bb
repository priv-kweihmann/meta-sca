inherit setuptools
require python-flawfinder-native.inc
