inherit python-dir
require python-flake8-sca-native.inc
