inherit setuptools
require python-bandit-native.inc

SRC_URI[md5sum] = "c6a6772d7afa0af8828b3384e73b7085"
SRC_URI[sha256sum] = "41e75315853507aa145d62a78a2a6c5e3240fe14ee7c601459d0df9418196065"
