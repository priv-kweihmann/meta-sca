inherit setuptools
require python-bandit-native.inc

SRC_URI[md5sum] = "f3b0c60198cf16f7c458de44b2bcdef4"
SRC_URI[sha256sum] = "fa1fee3cb60a3dca89b7a86c0be82af0e830def961728aba9290854fe18c1f90"
