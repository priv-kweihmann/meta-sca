inherit setuptools3
require python-bandit-native.inc

SRC_URI[md5sum] = "81ba3979ded1b421fa8d69e6faa06dcb"
SRC_URI[sha256sum] = "9413facfe9de1e1bd291d525c784e1beb1a55c9916b51dae12979af63a69ba4c"
