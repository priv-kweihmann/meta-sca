inherit setuptools
require python-bandit-native.inc

SRC_URI[md5sum] = "f923a498dd66e8d960cf68eacb3228dd"
SRC_URI[sha256sum] = "e50fb4ed4ee8a98b8329385e48e606fded0999a2cb3e2acb6e7213c962ff0de1"
