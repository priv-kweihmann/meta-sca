inherit setuptools
require python-looong-native.inc