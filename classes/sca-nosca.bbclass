# This class could be inherited into modules that should NOT be
# checked by sca

SCA_AVAILABLE_MODULES = ""
SCA_BLACKLIST_append = " ${PN}"