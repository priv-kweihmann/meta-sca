## SPDX-License-Identifier: BSD-2-Clause
## Copyright (c) 2020, Konrad Weihmann

# Shared configuration file for inspec module
SCA_INSPEC_MODULES ?= "\
                       apache-baseline \
                       linux-baseline \
                       mysql-baseline \
                       nginx-baseline \
                       php-baseline \
                       postgres-baseline \
                       ssh-baseline \
                      "