## This is a alias-recipe
GO_IMPORT = "gopkg.in/yaml.v2"
require github.com-go-yaml-yaml-native_${PV}.bb
