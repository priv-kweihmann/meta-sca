## This is a alias-recipe
GO_IMPORT = "gopkg.in-check.v1"
require github.com-go-check-check-native_${PV}.bb
