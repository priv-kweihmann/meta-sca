BBCLASSEXTEND += "nativesdk"